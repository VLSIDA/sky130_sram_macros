* Functional test stimulus file for 10ns period

* TT process corner
.lib "/software/PDKs/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "sky130_sram_1kbyte_1rw1r_32x256_8.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsky130_sram_1kbyte_1rw1r_32x256_8 din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a1_0 a1_1 a1_2 a1_3 a1_4 a1_5 a1_6 a1_7 CSB0 CSB1 WEB0 clk0 clk1 WMASK0_0 WMASK0_1 WMASK0_2 WMASK0_3 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 dout1_0 dout1_1 dout1_2 dout1_3 dout1_4 dout1_5 dout1_6 dout1_7 dout1_8 dout1_9 dout1_10 dout1_11 dout1_12 dout1_13 dout1_14 dout1_15 dout1_16 dout1_17 dout1_18 dout1_19 dout1_20 dout1_21 dout1_22 dout1_23 dout1_24 dout1_25 dout1_26 dout1_27 dout1_28 dout1_29 dout1_30 dout1_31 vdd gnd sky130_sram_1kbyte_1rw1r_32x256_8

* SRAM output loads
CD00 dout0_0  0 27.56f
CD01 dout0_1  0 27.56f
CD02 dout0_2  0 27.56f
CD03 dout0_3  0 27.56f
CD04 dout0_4  0 27.56f
CD05 dout0_5  0 27.56f
CD06 dout0_6  0 27.56f
CD07 dout0_7  0 27.56f
CD08 dout0_8  0 27.56f
CD09 dout0_9  0 27.56f
CD010 dout0_10  0 27.56f
CD011 dout0_11  0 27.56f
CD012 dout0_12  0 27.56f
CD013 dout0_13  0 27.56f
CD014 dout0_14  0 27.56f
CD015 dout0_15  0 27.56f
CD016 dout0_16  0 27.56f
CD017 dout0_17  0 27.56f
CD018 dout0_18  0 27.56f
CD019 dout0_19  0 27.56f
CD020 dout0_20  0 27.56f
CD021 dout0_21  0 27.56f
CD022 dout0_22  0 27.56f
CD023 dout0_23  0 27.56f
CD024 dout0_24  0 27.56f
CD025 dout0_25  0 27.56f
CD026 dout0_26  0 27.56f
CD027 dout0_27  0 27.56f
CD028 dout0_28  0 27.56f
CD029 dout0_29  0 27.56f
CD030 dout0_30  0 27.56f
CD031 dout0_31  0 27.56f
CD10 dout1_0  0 27.56f
CD11 dout1_1  0 27.56f
CD12 dout1_2  0 27.56f
CD13 dout1_3  0 27.56f
CD14 dout1_4  0 27.56f
CD15 dout1_5  0 27.56f
CD16 dout1_6  0 27.56f
CD17 dout1_7  0 27.56f
CD18 dout1_8  0 27.56f
CD19 dout1_9  0 27.56f
CD110 dout1_10  0 27.56f
CD111 dout1_11  0 27.56f
CD112 dout1_12  0 27.56f
CD113 dout1_13  0 27.56f
CD114 dout1_14  0 27.56f
CD115 dout1_15  0 27.56f
CD116 dout1_16  0 27.56f
CD117 dout1_17  0 27.56f
CD118 dout1_18  0 27.56f
CD119 dout1_19  0 27.56f
CD120 dout1_20  0 27.56f
CD121 dout1_21  0 27.56f
CD122 dout1_22  0 27.56f
CD123 dout1_23  0 27.56f
CD124 dout1_24  0 27.56f
CD125 dout1_25  0 27.56f
CD126 dout1_26  0 27.56f
CD127 dout1_27  0 27.56f
CD128 dout1_28  0 27.56f
CD129 dout1_29  0 27.56f
CD130 dout1_30  0 27.56f
CD131 dout1_31  0 27.56f

* Important signals for debug
* bl:	xsky130_sram_1kbyte_1rw1r_32x256_8.xbank0.bl_0_0
* br:	xsky130_sram_1kbyte_1rw1r_32x256_8.xbank0.br_0_0
* s_en:	xsky130_sram_1kbyte_1rw1r_32x256_8.s_en
* q:	xsky130_sram_1kbyte_1rw1r_32x256_8.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xsky130_sram_1kbyte_1rw1r_32x256_8.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 11101010111010001010010110001000  to  address 00000001 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 00111001101001110101101011000101  to  address 00000001 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 10111101011000101001100010011001  to  address 00000000 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 10111101011000101001100010011001 from address 00000000 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 00111001101001110101101011000101 from address 00000001 (from port 1) during cycle 4 (40ns - 50ns)
*	Writing (partial) 10011100000100001101110111110101  to  address 00000001 with mask bit 1110 (from port 0) during cycle 5 (50ns - 60ns)
*	Writing (partial) 10110000101001011011010101110000  to  address 00000000 with mask bit 1000 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 10011100000100001101110111000101 from address 00000001 (from port 1) during cycle 6 (60ns - 70ns)
*	Writing (partial) 11101101010100001111110111011001  to  address 00000001 with mask bit 1100 (from port 0) during cycle 7 (70ns - 80ns)
*	Writing (partial) 01000001011000100110100111110000  to  address 00000001 with mask bit 1101 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 10110000011000101001100010011001 from address 00000000 (from port 1) during cycle 8 (80ns - 90ns)
*	Writing 01011100010011110001011110110000  to  address 00000001 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 10110000011000101001100010011001 from address 00000000 (from port 1) during cycle 10 (100ns - 110ns)
*	Writing 01000010001001101100100100010001  to  address 11111110 (from port 0) during cycle 11 (110ns - 120ns)
*	Reading 01011100010011110001011110110000 from address 00000001 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing (partial) 11111110100100001000100010101110  to  address 11111110 with mask bit 0101 (from port 0) during cycle 13 (130ns - 140ns)
*	Reading 01011100010011110001011110110000 from address 00000001 (from port 0) during cycle 14 (140ns - 150ns)
*	Writing 00110101001000001001100001011100  to  address 00000001 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 00110101001000001001100001011100 from address 00000001 (from port 0) during cycle 17 (170ns - 180ns)
*	Writing (partial) 10010111011001000000000011011001  to  address 00000001 with mask bit 1101 (from port 0) during cycle 18 (180ns - 190ns)
*	Reading 10010111011001001001100011011001 from address 00000001 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing 11111001100010011001011010111000  to  address 11111101 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 10010111011001001001100011011001 from address 00000001 (from port 0) during cycle 21 (210ns - 220ns)
*	Writing (partial) 11101111001001010101101111101011  to  address 11111110 with mask bit 1101 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 10110000011000101001100010011001 from address 00000000 (from port 1) during cycle 22 (220ns - 230ns)
*	Reading 11101111001001011100100111101011 from address 11111110 (from port 0) during cycle 23 (230ns - 240ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 1) during cycle 23 (230ns - 240ns)
*	Writing 10101001011001000000001101101010  to  address 00000001 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 11101111001001011100100111101011 from address 11111110 (from port 1) during cycle 24 (240ns - 250ns)
*	Writing (partial) 01000100000001000110011011011011  to  address 00000001 with mask bit 0010 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 1) during cycle 25 (250ns - 260ns)
*	Writing 01000111001001010101010111111001  to  address 00000000 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 1) during cycle 26 (260ns - 270ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 0) during cycle 27 (270ns - 280ns)
*	Writing 11101111001011100110110111101010  to  address 11111110 (from port 0) during cycle 28 (280ns - 290ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 1) during cycle 29 (290ns - 300ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 0) during cycle 30 (300ns - 310ns)
*	Writing (partial) 10010100100110101011011100010110  to  address 11111110 with mask bit 1001 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 01000111001001010101010111111001 from address 00000000 (from port 1) during cycle 31 (310ns - 320ns)
*	Writing 11010010101010101101011101111001  to  address 00000000 (from port 0) during cycle 32 (320ns - 330ns)
*	Writing 11000010110100001101101011011111  to  address 11111110 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 1) during cycle 33 (330ns - 340ns)
*	Reading 11111001100010011001011010111000 from address 11111101 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 1) during cycle 34 (340ns - 350ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 1) during cycle 35 (350ns - 360ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 0) during cycle 36 (360ns - 370ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 1) during cycle 36 (360ns - 370ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 1) during cycle 37 (370ns - 380ns)
*	Writing 11100001111100000000100111111111  to  address 11111110 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 11100001111100000000100111111111 from address 11111110 (from port 0) during cycle 39 (390ns - 400ns)
*	Writing (partial) 10111101110101010011101011010110  to  address 11111101 with mask bit 0110 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 11100001111100000000100111111111 from address 11111110 (from port 1) during cycle 41 (410ns - 420ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 0) during cycle 42 (420ns - 430ns)
*	Writing 11100010011000110011011011010001  to  address 11111101 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 11100010011000110011011011010001 from address 11111101 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 11010010101010101101011101111001 from address 00000000 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 11100001111100000000100111111111 from address 11111110 (from port 1) during cycle 49 (490ns - 500ns)
*	Reading 11100010011000110011011011010001 from address 11111101 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 1) during cycle 50 (500ns - 510ns)
*	Writing (partial) 00100001100000010011000010010100  to  address 00000000 with mask bit 0100 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 10101001011001000110011001101010 from address 00000001 (from port 1) during cycle 51 (510ns - 520ns)
*	Writing 11010110010011110100001100100001  to  address 11111110 (from port 0) during cycle 53 (530ns - 540ns)
*	Writing (partial) 01001110010001111010001000101100  to  address 11111101 with mask bit 0111 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 11010110010011110100001100100001 from address 11111110 (from port 1) during cycle 54 (540ns - 550ns)
*	Reading 11100010010001111010001000101100 from address 11111101 (from port 1) during cycle 55 (550ns - 560ns)
*	Writing 00111010110100110001111001001011  to  address 00000001 (from port 0) during cycle 56 (560ns - 570ns)
*	Writing 10011000111101110001101010100100  to  address 00000000 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 11100010010001111010001000101100 from address 11111101 (from port 1) during cycle 57 (570ns - 580ns)
*	Reading 11100010010001111010001000101100 from address 11111101 (from port 1) during cycle 58 (580ns - 590ns)
*	Reading 10011000111101110001101010100100 from address 00000000 (from port 0) during cycle 59 (590ns - 600ns)
*	Reading 11100010010001111010001000101100 from address 11111101 (from port 1) during cycle 59 (590ns - 600ns)
*	Reading 10011000111101110001101010100100 from address 00000000 (from port 0) during cycle 60 (600ns - 610ns)
*	Reading 00111010110100110001111001001011 from address 00000001 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing (partial) 00011111101001011101101100101101  to  address 11111101 with mask bit 0100 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 11010110010011110100001100100001 from address 11111110 (from port 1) during cycle 62 (620ns - 630ns)
*	Writing (partial) 01101110011111111111101000001101  to  address 11111110 with mask bit 0110 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 10011000111101110001101010100100 from address 00000000 (from port 1) during cycle 63 (630ns - 640ns)
*	Reading 11010110011111111111101000100001 from address 11111110 (from port 0) during cycle 64 (640ns - 650ns)
*	Reading 00111010110100110001111001001011 from address 00000001 (from port 1) during cycle 64 (640ns - 650ns)
*	Writing (partial) 11000001001011100011011101001101  to  address 11111101 with mask bit 0011 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 11010110011111111111101000100001 from address 11111110 (from port 1) during cycle 65 (650ns - 660ns)
*	Writing 01101010011101011101010011110111  to  address 11111110 (from port 0) during cycle 66 (660ns - 670ns)
*	Writing (partial) 11101100001001000110100101010011  to  address 00000000 with mask bit 0110 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 01101010011101011101010011110111 from address 11111110 (from port 1) during cycle 67 (670ns - 680ns)
*	Reading 10011000001001000110100110100100 from address 00000000 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 11100010101001010011011101001101 from address 11111101 (from port 1) during cycle 68 (680ns - 690ns)
*	Reading 10011000001001000110100110100100 from address 00000000 (from port 0) during cycle 69 (690ns - 700ns)
*	Reading 01101010011101011101010011110111 from address 11111110 (from port 1) during cycle 70 (700ns - 710ns)
*	Writing (partial) 01101101010100001010101000111111  to  address 11111101 with mask bit 1101 (from port 0) during cycle 71 (710ns - 720ns)
*	Writing (partial) 00000000101001101000011101100000  to  address 00000001 with mask bit 1100 (from port 0) during cycle 72 (720ns - 730ns)
*	Reading 01101010011101011101010011110111 from address 11111110 (from port 1) during cycle 72 (720ns - 730ns)
*	Reading 00000000101001100001111001001011 from address 00000001 (from port 1) during cycle 73 (730ns - 740ns)
*	Reading 10011000001001000110100110100100 from address 00000000 (from port 1) during cycle 74 (740ns - 750ns)
*	Writing 10010101010100101011111001111011  to  address 00000001 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 01101010011101011101010011110111 from address 11111110 (from port 1) during cycle 75 (750ns - 760ns)
*	Writing (partial) 10001011111000001000001111100110  to  address 11111110 with mask bit 1110 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing 10010111100000001101111101010100  to  address 00000001 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 10011000001001000110100110100100 from address 00000000 (from port 1) during cycle 78 (780ns - 790ns)
*	Writing (partial) 00100000100010010111101011001000  to  address 11111110 with mask bit 0111 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing (partial) 01101001110000111010111110011101  to  address 00000001 with mask bit 0011 (from port 0) during cycle 80 (800ns - 810ns)
*	Writing (partial) 01111101100010000010011001110001  to  address 00000001 with mask bit 1101 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 01101101010100000011011100111111 from address 11111101 (from port 1) during cycle 81 (810ns - 820ns)
*	Writing 10110100101110111011110111100010  to  address 11111101 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 10110100101110111011110111100010 from address 11111101 (from port 0) during cycle 83 (830ns - 840ns)
*	Reading 10001011100010010111101011001000 from address 11111110 (from port 1) during cycle 83 (830ns - 840ns)
*	Writing 00111011111110000011100010111000  to  address 11111110 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 10110100101110111011110111100010 from address 11111101 (from port 1) during cycle 84 (840ns - 850ns)
*	Writing 00011101001011011000100010000111  to  address 11111110 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing (partial) 00110110011010001010111010001010  to  address 00000001 with mask bit 0010 (from port 0) during cycle 86 (860ns - 870ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 1) during cycle 86 (860ns - 870ns)
*	Reading 10110100101110111011110111100010 from address 11111101 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 1) during cycle 87 (870ns - 880ns)
*	Writing (partial) 11101111001110000000000010111001  to  address 00000000 with mask bit 0110 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 01111101100010001010111001110001 from address 00000001 (from port 1) during cycle 89 (890ns - 900ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 10011000001110000000000010100100 from address 00000000 (from port 1) during cycle 90 (900ns - 910ns)
*	Reading 10110100101110111011110111100010 from address 11111101 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 0) during cycle 92 (920ns - 930ns)
*	Writing 01001011000000110101011101011100  to  address 11111101 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 01111101100010001010111001110001 from address 00000001 (from port 1) during cycle 94 (940ns - 950ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 10011000001110000000000010100100 from address 00000000 (from port 1) during cycle 96 (960ns - 970ns)
*	Reading 10011000001110000000000010100100 from address 00000000 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 10011000001110000000000010100100 from address 00000000 (from port 1) during cycle 98 (980ns - 990ns)
*	Writing 11100001001000110011110001001111  to  address 00000000 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 1) during cycle 100 (1000ns - 1010ns)
*	Writing 01110101111111000110011001011110  to  address 00000001 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Reading 11100001001000110011110001001111 from address 00000000 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 01001011000000110101011101011100 from address 11111101 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Reading 01110101111111000110011001011110 from address 00000001 (from port 1) during cycle 103 (1030ns - 1040ns)
*	Reading 00011101001011011000100010000111 from address 11111110 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 11100001001000110011110001001111 from address 00000000 (from port 1) during cycle 106 (1060ns - 1070ns)
*	Writing 00000010100001000101010010100000  to  address 11111101 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 01110101111111000110011001011110 from address 00000001 (from port 1) during cycle 107 (1070ns - 1080ns)
*	Writing (partial) 01010100001011110111110100001000  to  address 11111110 with mask bit 0110 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 00011101001011110111110110000111 from address 11111110 (from port 1) during cycle 109 (1090ns - 1100ns)
*	Writing 00110010001100001000100000110100  to  address 00000000 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 00110010001100001000100000110100 from address 00000000 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 00011101001011110111110110000111 from address 11111110 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 00000010100001000101010010100000 from address 11111101 (from port 1) during cycle 112 (1120ns - 1130ns)
*	Writing 10010111101011111010011001101010  to  address 11111101 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 10010111101011111010011001101010 from address 11111101 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 00011101001011110111110110000111 from address 11111110 (from port 1) during cycle 114 (1140ns - 1150ns)
*	Reading 00110010001100001000100000110100 from address 00000000 (from port 1) during cycle 115 (1150ns - 1160ns)
*	Writing 11000010101010001110110001000100  to  address 11111101 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Reading 01110101111111000110011001011110 from address 00000001 (from port 1) during cycle 117 (1170ns - 1180ns)
*	Reading 01110101111111000110011001011110 from address 00000001 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Reading 00110010001100001000100000110100 from address 00000000 (from port 1) during cycle 118 (1180ns - 1190ns)
*	Writing 11100111001000101000000011110001  to  address 11111110 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Writing (partial) 00110111010111001110100000000110  to  address 00000001 with mask bit 0011 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 11100111001000101000000011110001 from address 11111110 (from port 1) during cycle 123 (1230ns - 1240ns)
*	Writing (partial) 11110011101111000100011111100000  to  address 00000001 with mask bit 0100 (from port 0) during cycle 124 (1240ns - 1250ns)
*	Writing 10000110100001110100001001111101  to  address 00000000 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 11100111001000101000000011110001 from address 11111110 (from port 1) during cycle 127 (1270ns - 1280ns)
*	Reading 11100111001000101000000011110001 from address 11111110 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing (partial) 01010010010001111111000011100000  to  address 11111110 with mask bit 0101 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Writing 11000001001111010111111000101001  to  address 00000001 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 1) during cycle 131 (1310ns - 1320ns)
*	Writing (partial) 01010110111111100011100101001001  to  address 00000000 with mask bit 1000 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 11100111010001111000000011100000 from address 11111110 (from port 1) during cycle 132 (1320ns - 1330ns)
*	Reading 11100111010001111000000011100000 from address 11111110 (from port 1) during cycle 133 (1330ns - 1340ns)
*	Writing (partial) 00101000010011001010000111011001  to  address 00000000 with mask bit 0001 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 1) during cycle 135 (1350ns - 1360ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 11000010101010001110110001000100 from address 11111101 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing (partial) 01100110110101001100011100010001  to  address 11111110 with mask bit 0011 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Writing (partial) 10111011000000101100001010110001  to  address 11111101 with mask bit 0001 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Reading 11000010101010001110110010110001 from address 11111101 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Writing 01000111011000110011000011011000  to  address 00000001 (from port 0) during cycle 145 (1450ns - 1460ns)
*	Reading 11000010101010001110110010110001 from address 11111101 (from port 1) during cycle 145 (1450ns - 1460ns)
*	Writing 11000011100110010111001100100010  to  address 00000001 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 147 (1470ns - 1480ns)
*	Reading 11000010101010001110110010110001 from address 11111101 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 148 (1480ns - 1490ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 149 (1490ns - 1500ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 150 (1500ns - 1510ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 151 (1510ns - 1520ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 11000011100110010111001100100010 from address 00000001 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 11000011100110010111001100100010 from address 00000001 (from port 1) during cycle 153 (1530ns - 1540ns)
*	Writing 10100101010001110111000100010100  to  address 11111101 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 1) during cycle 157 (1570ns - 1580ns)
*	Reading 11100111010001111100011100010001 from address 11111110 (from port 1) during cycle 158 (1580ns - 1590ns)
*	Writing (partial) 10001100011000011101001110111001  to  address 11111110 with mask bit 0100 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 11000011100110010111001100100010 from address 00000001 (from port 1) during cycle 159 (1590ns - 1600ns)
*	Reading 10100101010001110111000100010100 from address 11111101 (from port 1) during cycle 160 (1600ns - 1610ns)
*	Reading 11000011100110010111001100100010 from address 00000001 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 11100111011000011100011100010001 from address 11111110 (from port 1) during cycle 161 (1610ns - 1620ns)
*	Reading 11000011100110010111001100100010 from address 00000001 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 01010110100001110100001011011001 from address 00000000 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Writing 10000111001001010010011000010000  to  address 00000001 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Writing 11001110110110010010100101000010  to  address 00000000 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Reading 11100111011000011100011100010001 from address 11111110 (from port 1) during cycle 168 (1680ns - 1690ns)
*	Writing 11111100100000011011100011011010  to  address 00000000 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 10100101010001110111000100010100 from address 11111101 (from port 1) during cycle 170 (1700ns - 1710ns)
*	Writing (partial) 11100101011100001111110110101111  to  address 11111101 with mask bit 1010 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 11100111011000011100011100010001 from address 11111110 (from port 1) during cycle 171 (1710ns - 1720ns)
*	Writing 00001111110111110011101101011110  to  address 00000000 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 1) during cycle 173 (1730ns - 1740ns)
*	Writing (partial) 10011111011000111011001001100100  to  address 11111101 with mask bit 0111 (from port 0) during cycle 174 (1740ns - 1750ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Reading 11100101011000111011001001100100 from address 11111101 (from port 1) during cycle 178 (1780ns - 1790ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 11100101011000111011001001100100 from address 11111101 (from port 0) during cycle 180 (1800ns - 1810ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 1) during cycle 180 (1800ns - 1810ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 1) during cycle 181 (1810ns - 1820ns)
*	Writing 10100100100011101000001110100010  to  address 11111110 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Reading 11100101011000111011001001100100 from address 11111101 (from port 1) during cycle 182 (1820ns - 1830ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 10100100100011101000001110100010 from address 11111110 (from port 1) during cycle 183 (1830ns - 1840ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 1) during cycle 184 (1840ns - 1850ns)
*	Writing (partial) 00111010101101110110001000010101  to  address 11111101 with mask bit 0010 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 10100100100011101000001110100010 from address 11111110 (from port 1) during cycle 185 (1850ns - 1860ns)
*	Reading 00001111110111110011101101011110 from address 00000000 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Writing (partial) 11101011101101001110000011101101  to  address 00000000 with mask bit 0100 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 00001111101101000011101101011110 from address 00000000 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Reading 10000111001001010010011000010000 from address 00000001 (from port 0) during cycle 189 (1890ns - 1900ns)
*	Reading 11100101011000110110001001100100 from address 11111101 (from port 1) during cycle 189 (1890ns - 1900ns)
*	Writing 11111010101101100000010001101100  to  address 00000001 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 10100100100011101000001110100010 from address 11111110 (from port 1) during cycle 190 (1900ns - 1910ns)
*	Reading 10100100100011101000001110100010 from address 11111110 (from port 1) during cycle 191 (1910ns - 1920ns)
*	Reading 11111010101101100000010001101100 from address 00000001 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 11100101011000110110001001100100 from address 11111101 (from port 1) during cycle 192 (1920ns - 1930ns)
*	Writing (partial) 10011011010111110010100101110101  to  address 11111110 with mask bit 0010 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 10100100100011100010100110100010 from address 11111110 (from port 1) during cycle 194 (1940ns - 1950ns)
*	Reading 00001111101101000011101101011110 from address 00000000 (from port 1) during cycle 195 (1950ns - 1960ns)
*	Writing 11001011011110001110010100011000  to  address 11111101 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Reading 11111010101101100000010001101100 from address 00000001 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing 10101111010111011000011111111100  to  address 00000001 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Reading 00001111101101000011101101011110 from address 00000000 (from port 1) during cycle 198 (1980ns - 1990ns)
*	Writing 01110110001010011100111100100111  to  address 00000001 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Writing 01110000110101111000110101101011  to  address 11111110 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Reading 11001011011110001110010100011000 from address 11111101 (from port 1) during cycle 200 (2000ns - 2010ns)
*	Reading 00001111101101000011101101011110 from address 00000000 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Reading 00001111101101000011101101011110 from address 00000000 (from port 1) during cycle 201 (2010ns - 2020ns)
*	Reading 01110000110101111000110101101011 from address 11111110 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Reading 01110110001010011100111100100111 from address 00000001 (from port 1) during cycle 202 (2020ns - 2030ns)
*	Reading 01110110001010011100111100100111 from address 00000001 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Writing (partial) 00001111011110000100010000101101  to  address 00000000 with mask bit 0001 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 0), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 0), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 0), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 1), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 0), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 0), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 0), (80, 1), (90, 1), (100, 0), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 1), (2050, 1)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 0), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 1), (140, 1), (150, 1), (160, 0), (170, 0), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 0), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 0), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 1), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 0.0v 29.495n 0.0v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 0), (120, 1), (130, 0), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 0), (270, 1), (280, 0), (290, 0), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 1), (420, 0), (430, 1), (440, 1), (450, 1), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 0), (770, 0), (780, 1), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 1), (920, 0), (930, 0), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 1), (1020, 0), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 1), (1680, 0), (1690, 0), (1700, 1), (1710, 1), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 1), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 0), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 0.0v 919.495n 0.0v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 1), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 0), (430, 1), (440, 0), (450, 0), (460, 0), (470, 1), (480, 0), (490, 0), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 0), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 0), (980, 1), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 0), (1380, 0), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 0), (1480, 1), (1490, 1), (1500, 1), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 1), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 1), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 0), (2040, 0), (2050, 0)]
Va0_7  a0_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 0.0v 129.495n 0.0v 129.505n 1.8v 139.495n 1.8v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 0.0v 219.495n 0.0v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 1.8v 479.495n 1.8v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 1), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 0), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 1), (1040, 1), (1050, 1), (1060, 0), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 1), (1900, 0), (1910, 0), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Va1_0  a1_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 0.0v 459.495n 0.0v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 0.0v 1009.495n 0.0v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 0), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_1  a1_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 0.0v 299.495n 0.0v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 0.0v 559.495n 0.0v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_2  a1_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_3  a1_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_4  a1_4  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_5  a1_5  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_6  a1_6  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 0), (330, 1), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 1), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va1_7  a1_7  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 1.8v 339.495n 1.8v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 0.0v 409.495n 0.0v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 0.0v 539.495n 0.0v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 0.0v 969.495n 0.0v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 0.0v 1059.495n 0.0v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 0.0v 1169.495n 0.0v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 0.0v 1559.495n 0.0v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 0), (400, 1), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 1), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 0), (720, 0), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 1), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 0), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 0), (1600, 1), (1610, 0), (1620, 1), (1630, 1), (1640, 0), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 1), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 0.0v 49.495n 0.0v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 0.0v 129.495n 0.0v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 0.0v 179.495n 0.0v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 0.0v 209.495n 0.0v 209.505n 0.0v 219.495n 0.0v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 0.0v 279.495n 0.0v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 0.0v 309.495n 0.0v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 1.8v 359.495n 1.8v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 0.0v 389.495n 0.0v 389.505n 0.0v 399.495n 0.0v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 0.0v 439.495n 0.0v 439.505n 0.0v 449.495n 0.0v 449.505n 1.8v 459.495n 1.8v 459.505n 0.0v 469.495n 0.0v 469.505n 0.0v 479.495n 0.0v 479.505n 0.0v 489.495n 0.0v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 0.0v 599.495n 0.0v 599.505n 0.0v 609.495n 0.0v 609.505n 0.0v 619.495n 0.0v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 0.0v 959.495n 0.0v 959.505n 1.8v 969.495n 1.8v 969.505n 0.0v 979.495n 0.0v 979.505n 0.0v 989.495n 0.0v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 0.0v 1029.495n 0.0v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 0.0v 1049.495n 0.0v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 0.0v 1119.495n 0.0v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 0.0v 1269.495n 0.0v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 0.0v 1289.495n 0.0v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 0.0v 1529.495n 0.0v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 0.0v 1569.495n 0.0v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 0.0v 1979.495n 0.0v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 0.0v 2039.495n 0.0v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 1), (20, 1), (30, 1), (40, 0), (50, 1), (60, 0), (70, 1), (80, 0), (90, 1), (100, 0), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 1), (280, 1), (290, 0), (300, 1), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 0), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 0), (500, 0), (510, 0), (520, 1), (530, 1), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 0), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 1), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 0), (760, 1), (770, 1), (780, 0), (790, 1), (800, 1), (810, 0), (820, 1), (830, 0), (840, 0), (850, 1), (860, 0), (870, 0), (880, 1), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 0), (970, 1), (980, 0), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 0), (1040, 1), (1050, 1), (1060, 0), (1070, 0), (1080, 1), (1090, 0), (1100, 1), (1110, 1), (1120, 0), (1130, 1), (1140, 0), (1150, 0), (1160, 1), (1170, 0), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 0), (1460, 1), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 1), (1730, 0), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 0), (1790, 1), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 0), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
VCSB1 CSB1 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 0.0v 49.495n 0.0v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 0.0v 299.495n 0.0v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 0.0v 339.495n 0.0v 339.505n 0.0v 349.495n 0.0v 349.505n 0.0v 359.495n 0.0v 359.505n 0.0v 369.495n 0.0v 369.505n 0.0v 379.495n 0.0v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 0.0v 499.495n 0.0v 499.505n 0.0v 509.495n 0.0v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 0.0v 579.495n 0.0v 579.505n 0.0v 589.495n 0.0v 589.505n 0.0v 599.495n 0.0v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 1.8v 699.495n 1.8v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 0.0v 759.495n 0.0v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 0.0v 839.495n 0.0v 839.505n 0.0v 849.495n 0.0v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 0.0v 969.495n 0.0v 969.505n 1.8v 979.495n 1.8v 979.505n 0.0v 989.495n 0.0v 989.505n 1.8v 999.495n 1.8v 999.505n 0.0v 1009.495n 0.0v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 0.0v 1039.495n 0.0v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 0.0v 1069.495n 0.0v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 0.0v 1129.495n 0.0v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 0.0v 1149.495n 0.0v 1149.505n 0.0v 1159.495n 0.0v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 0.0v 1189.495n 0.0v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 0.0v 1279.495n 0.0v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 0.0v 1319.495n 0.0v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 0.0v 1479.495n 0.0v 1479.505n 0.0v 1489.495n 0.0v 1489.505n 0.0v 1499.495n 0.0v 1499.505n 0.0v 1509.495n 0.0v 1509.505n 0.0v 1519.495n 0.0v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 0.0v 1539.495n 0.0v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 0.0v 1579.495n 0.0v 1579.505n 0.0v 1589.495n 0.0v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 0.0v 1709.495n 0.0v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 0.0v 1739.495n 0.0v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 0.0v 1839.495n 0.0v 1839.505n 0.0v 1849.495n 0.0v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 0.0v 1919.495n 0.0v 1919.505n 0.0v 1929.495n 0.0v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 0.0v 2019.495n 0.0v 2019.505n 0.0v 2029.495n 0.0v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 1), (100, 0), (110, 0), (120, 1), (130, 0), (140, 1), (150, 1), (160, 0), (170, 1), (180, 0), (190, 1), (200, 0), (210, 1), (220, 0), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 0), (290, 1), (300, 1), (310, 0), (320, 0), (330, 0), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 1), (400, 1), (410, 0), (420, 1), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 1), (740, 1), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 0), (950, 1), (960, 1), (970, 1), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 1), (1100, 0), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 0), (1460, 0), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 0), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 9.495n 1.8v 9.505n 0.0v 19.495n 0.0v 19.505n 0.0v 29.495n 0.0v 29.505n 0.0v 39.495n 0.0v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 1.8v 99.495n 1.8v 99.505n 0.0v 109.495n 0.0v 109.505n 0.0v 119.495n 0.0v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 0.0v 169.495n 0.0v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 1.8v 199.495n 1.8v 199.505n 0.0v 209.495n 0.0v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 1.8v 239.495n 1.8v 239.505n 0.0v 249.495n 0.0v 249.505n 0.0v 259.495n 0.0v 259.505n 0.0v 269.495n 0.0v 269.505n 1.8v 279.495n 1.8v 279.505n 0.0v 289.495n 0.0v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 0.0v 329.495n 0.0v 329.505n 0.0v 339.495n 0.0v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 0.0v 389.495n 0.0v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 1.8v 429.495n 1.8v 429.505n 0.0v 439.495n 0.0v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 1.8v 529.495n 1.8v 529.505n 0.0v 539.495n 0.0v 539.505n 0.0v 549.495n 0.0v 549.505n 1.8v 559.495n 1.8v 559.505n 0.0v 569.495n 0.0v 569.505n 0.0v 579.495n 0.0v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 0.0v 669.495n 0.0v 669.505n 0.0v 679.495n 0.0v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 0.0v 759.495n 0.0v 759.505n 0.0v 769.495n 0.0v 769.505n 1.8v 779.495n 1.8v 779.505n 0.0v 789.495n 0.0v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 0.0v 819.495n 0.0v 819.505n 0.0v 829.495n 0.0v 829.505n 1.8v 839.495n 1.8v 839.505n 0.0v 849.495n 0.0v 849.505n 0.0v 859.495n 0.0v 859.505n 0.0v 869.495n 0.0v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 0.0v 899.495n 0.0v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 0.0v 949.495n 0.0v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 0.0v 999.495n 0.0v 999.505n 1.8v 1009.495n 1.8v 1009.505n 0.0v 1019.495n 0.0v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 0.0v 1079.495n 0.0v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 0.0v 1109.495n 0.0v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 0.0v 1139.495n 0.0v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 0.0v 1179.495n 0.0v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 0.0v 1199.495n 0.0v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 0.0v 1259.495n 0.0v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 0.0v 1309.495n 0.0v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 0.0v 1459.495n 0.0v 1459.505n 0.0v 1469.495n 0.0v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 0.0v 1549.495n 0.0v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 0.0v 1679.495n 0.0v 1679.505n 0.0v 1689.495n 0.0v 1689.505n 0.0v 1699.495n 0.0v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 0.0v 1729.495n 0.0v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 0.0v 1829.495n 0.0v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 0.0v 1909.495n 0.0v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 0.0v 1969.495n 0.0v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 0.0v 1989.495n 0.0v 1989.505n 0.0v 1999.495n 0.0v 1999.505n 0.0v 2009.495n 0.0v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 1.8v )

* Generation of wmask signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 0), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWMASK0_0  WMASK0_0  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 0.0v 59.495n 0.0v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 0.0v 769.495n 0.0v 769.505n 0.0v 779.495n 0.0v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 1.8v 1359.495n 1.8v 1359.505n 1.8v 1369.495n 1.8v 1369.505n 1.8v 1379.495n 1.8v 1379.505n 1.8v 1389.495n 1.8v 1389.505n 1.8v 1399.495n 1.8v 1399.505n 1.8v 1409.495n 1.8v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 1.8v 1429.495n 1.8v 1429.505n 1.8v 1439.495n 1.8v 1439.505n 1.8v 1449.495n 1.8v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 1.8v 2049.495n 1.8v 2049.505n 1.8v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 0), (190, 0), (200, 1), (210, 1), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
VWMASK0_1  WMASK0_1  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 0.0v 79.495n 0.0v 79.505n 0.0v 89.495n 0.0v 89.505n 0.0v 99.495n 0.0v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 0.0v 189.495n 0.0v 189.505n 0.0v 199.495n 0.0v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 0.0v 229.495n 0.0v 229.505n 0.0v 239.495n 0.0v 239.505n 1.8v 249.495n 1.8v 249.505n 1.8v 259.495n 1.8v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 1.8v 659.495n 1.8v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 0.0v 719.495n 0.0v 719.505n 0.0v 729.495n 0.0v 729.505n 0.0v 739.495n 0.0v 739.505n 0.0v 749.495n 0.0v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 1.8v 809.495n 1.8v 809.505n 0.0v 819.495n 0.0v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 1.8v 869.495n 1.8v 869.505n 1.8v 879.495n 1.8v 879.505n 1.8v 889.495n 1.8v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 1.8v 1209.495n 1.8v 1209.505n 1.8v 1219.495n 1.8v 1219.505n 1.8v 1229.495n 1.8v 1229.505n 1.8v 1239.495n 1.8v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 1.8v 1419.495n 1.8v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 1.8v 1859.495n 1.8v 1859.505n 1.8v 1869.495n 1.8v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 1.8v 1939.495n 1.8v 1939.505n 1.8v 1949.495n 1.8v 1949.505n 1.8v 1959.495n 1.8v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 0), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 0), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 0), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
VWMASK0_2  WMASK0_2  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 0.0v 69.495n 0.0v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 1.8v 139.495n 1.8v 139.505n 1.8v 149.495n 1.8v 149.505n 1.8v 159.495n 1.8v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 0.0v 319.495n 0.0v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 1.8v 419.495n 1.8v 419.505n 1.8v 429.495n 1.8v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 1.8v 519.495n 1.8v 519.505n 1.8v 529.495n 1.8v 529.505n 1.8v 539.495n 1.8v 539.505n 1.8v 549.495n 1.8v 549.505n 1.8v 559.495n 1.8v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 1.8v 629.495n 1.8v 629.505n 1.8v 639.495n 1.8v 639.505n 1.8v 649.495n 1.8v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 1.8v 679.495n 1.8v 679.505n 1.8v 689.495n 1.8v 689.505n 1.8v 699.495n 1.8v 699.505n 1.8v 709.495n 1.8v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 1.8v 799.495n 1.8v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 1.8v 899.495n 1.8v 899.505n 1.8v 909.495n 1.8v 909.505n 1.8v 919.495n 1.8v 919.505n 1.8v 929.495n 1.8v 929.505n 1.8v 939.495n 1.8v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 1.8v 1089.495n 1.8v 1089.505n 1.8v 1099.495n 1.8v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 1.8v 1249.495n 1.8v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 1.8v 1299.495n 1.8v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 0.0v 1329.495n 0.0v 1329.505n 0.0v 1339.495n 0.0v 1339.505n 0.0v 1349.495n 0.0v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 1.8v 1599.495n 1.8v 1599.505n 1.8v 1609.495n 1.8v 1609.505n 1.8v 1619.495n 1.8v 1619.505n 1.8v 1629.495n 1.8v 1629.505n 1.8v 1639.495n 1.8v 1639.505n 1.8v 1649.495n 1.8v 1649.505n 1.8v 1659.495n 1.8v 1659.505n 1.8v 1669.495n 1.8v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 0.0v 1719.495n 0.0v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 1.8v 1749.495n 1.8v 1749.505n 1.8v 1759.495n 1.8v 1759.505n 1.8v 1769.495n 1.8v 1769.505n 1.8v 1779.495n 1.8v 1779.505n 1.8v 1789.495n 1.8v 1789.505n 1.8v 1799.495n 1.8v 1799.505n 1.8v 1809.495n 1.8v 1809.505n 1.8v 1819.495n 1.8v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 1.8v 1879.495n 1.8v 1879.505n 1.8v 1889.495n 1.8v 1889.505n 1.8v 1899.495n 1.8v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 0), (140, 0), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 1), (1910, 1), (1920, 1), (1930, 0), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 0), (2050, 0)]
VWMASK0_3  WMASK0_3  0 PWL (0n 0.0v 9.495n 0.0v 9.505n 1.8v 19.495n 1.8v 19.505n 1.8v 29.495n 1.8v 29.505n 1.8v 39.495n 1.8v 39.505n 1.8v 49.495n 1.8v 49.505n 1.8v 59.495n 1.8v 59.505n 1.8v 69.495n 1.8v 69.505n 1.8v 79.495n 1.8v 79.505n 1.8v 89.495n 1.8v 89.505n 1.8v 99.495n 1.8v 99.505n 1.8v 109.495n 1.8v 109.505n 1.8v 119.495n 1.8v 119.505n 1.8v 129.495n 1.8v 129.505n 0.0v 139.495n 0.0v 139.505n 0.0v 149.495n 0.0v 149.505n 0.0v 159.495n 0.0v 159.505n 1.8v 169.495n 1.8v 169.505n 1.8v 179.495n 1.8v 179.505n 1.8v 189.495n 1.8v 189.505n 1.8v 199.495n 1.8v 199.505n 1.8v 209.495n 1.8v 209.505n 1.8v 219.495n 1.8v 219.505n 1.8v 229.495n 1.8v 229.505n 1.8v 239.495n 1.8v 239.505n 1.8v 249.495n 1.8v 249.505n 0.0v 259.495n 0.0v 259.505n 1.8v 269.495n 1.8v 269.505n 1.8v 279.495n 1.8v 279.505n 1.8v 289.495n 1.8v 289.505n 1.8v 299.495n 1.8v 299.505n 1.8v 309.495n 1.8v 309.505n 1.8v 319.495n 1.8v 319.505n 1.8v 329.495n 1.8v 329.505n 1.8v 339.495n 1.8v 339.505n 1.8v 349.495n 1.8v 349.505n 1.8v 359.495n 1.8v 359.505n 1.8v 369.495n 1.8v 369.505n 1.8v 379.495n 1.8v 379.505n 1.8v 389.495n 1.8v 389.505n 1.8v 399.495n 1.8v 399.505n 1.8v 409.495n 1.8v 409.505n 0.0v 419.495n 0.0v 419.505n 0.0v 429.495n 0.0v 429.505n 1.8v 439.495n 1.8v 439.505n 1.8v 449.495n 1.8v 449.505n 1.8v 459.495n 1.8v 459.505n 1.8v 469.495n 1.8v 469.505n 1.8v 479.495n 1.8v 479.505n 1.8v 489.495n 1.8v 489.505n 1.8v 499.495n 1.8v 499.505n 1.8v 509.495n 1.8v 509.505n 0.0v 519.495n 0.0v 519.505n 0.0v 529.495n 0.0v 529.505n 1.8v 539.495n 1.8v 539.505n 0.0v 549.495n 0.0v 549.505n 0.0v 559.495n 0.0v 559.505n 1.8v 569.495n 1.8v 569.505n 1.8v 579.495n 1.8v 579.505n 1.8v 589.495n 1.8v 589.505n 1.8v 599.495n 1.8v 599.505n 1.8v 609.495n 1.8v 609.505n 1.8v 619.495n 1.8v 619.505n 0.0v 629.495n 0.0v 629.505n 0.0v 639.495n 0.0v 639.505n 0.0v 649.495n 0.0v 649.505n 0.0v 659.495n 0.0v 659.505n 1.8v 669.495n 1.8v 669.505n 0.0v 679.495n 0.0v 679.505n 0.0v 689.495n 0.0v 689.505n 0.0v 699.495n 0.0v 699.505n 0.0v 709.495n 0.0v 709.505n 1.8v 719.495n 1.8v 719.505n 1.8v 729.495n 1.8v 729.505n 1.8v 739.495n 1.8v 739.505n 1.8v 749.495n 1.8v 749.505n 1.8v 759.495n 1.8v 759.505n 1.8v 769.495n 1.8v 769.505n 1.8v 779.495n 1.8v 779.505n 1.8v 789.495n 1.8v 789.505n 0.0v 799.495n 0.0v 799.505n 0.0v 809.495n 0.0v 809.505n 1.8v 819.495n 1.8v 819.505n 1.8v 829.495n 1.8v 829.505n 1.8v 839.495n 1.8v 839.505n 1.8v 849.495n 1.8v 849.505n 1.8v 859.495n 1.8v 859.505n 0.0v 869.495n 0.0v 869.505n 0.0v 879.495n 0.0v 879.505n 0.0v 889.495n 0.0v 889.505n 0.0v 899.495n 0.0v 899.505n 0.0v 909.495n 0.0v 909.505n 0.0v 919.495n 0.0v 919.505n 0.0v 929.495n 0.0v 929.505n 0.0v 939.495n 0.0v 939.505n 1.8v 949.495n 1.8v 949.505n 1.8v 959.495n 1.8v 959.505n 1.8v 969.495n 1.8v 969.505n 1.8v 979.495n 1.8v 979.505n 1.8v 989.495n 1.8v 989.505n 1.8v 999.495n 1.8v 999.505n 1.8v 1009.495n 1.8v 1009.505n 1.8v 1019.495n 1.8v 1019.505n 1.8v 1029.495n 1.8v 1029.505n 1.8v 1039.495n 1.8v 1039.505n 1.8v 1049.495n 1.8v 1049.505n 1.8v 1059.495n 1.8v 1059.505n 1.8v 1069.495n 1.8v 1069.505n 1.8v 1079.495n 1.8v 1079.505n 0.0v 1089.495n 0.0v 1089.505n 0.0v 1099.495n 0.0v 1099.505n 1.8v 1109.495n 1.8v 1109.505n 1.8v 1119.495n 1.8v 1119.505n 1.8v 1129.495n 1.8v 1129.505n 1.8v 1139.495n 1.8v 1139.505n 1.8v 1149.495n 1.8v 1149.505n 1.8v 1159.495n 1.8v 1159.505n 1.8v 1169.495n 1.8v 1169.505n 1.8v 1179.495n 1.8v 1179.505n 1.8v 1189.495n 1.8v 1189.505n 1.8v 1199.495n 1.8v 1199.505n 0.0v 1209.495n 0.0v 1209.505n 0.0v 1219.495n 0.0v 1219.505n 0.0v 1229.495n 0.0v 1229.505n 0.0v 1239.495n 0.0v 1239.505n 0.0v 1249.495n 0.0v 1249.505n 1.8v 1259.495n 1.8v 1259.505n 1.8v 1269.495n 1.8v 1269.505n 1.8v 1279.495n 1.8v 1279.505n 1.8v 1289.495n 1.8v 1289.505n 0.0v 1299.495n 0.0v 1299.505n 1.8v 1309.495n 1.8v 1309.505n 1.8v 1319.495n 1.8v 1319.505n 1.8v 1329.495n 1.8v 1329.505n 1.8v 1339.495n 1.8v 1339.505n 1.8v 1349.495n 1.8v 1349.505n 0.0v 1359.495n 0.0v 1359.505n 0.0v 1369.495n 0.0v 1369.505n 0.0v 1379.495n 0.0v 1379.505n 0.0v 1389.495n 0.0v 1389.505n 0.0v 1399.495n 0.0v 1399.505n 0.0v 1409.495n 0.0v 1409.505n 0.0v 1419.495n 0.0v 1419.505n 0.0v 1429.495n 0.0v 1429.505n 0.0v 1439.495n 0.0v 1439.505n 0.0v 1449.495n 0.0v 1449.505n 1.8v 1459.495n 1.8v 1459.505n 1.8v 1469.495n 1.8v 1469.505n 1.8v 1479.495n 1.8v 1479.505n 1.8v 1489.495n 1.8v 1489.505n 1.8v 1499.495n 1.8v 1499.505n 1.8v 1509.495n 1.8v 1509.505n 1.8v 1519.495n 1.8v 1519.505n 1.8v 1529.495n 1.8v 1529.505n 1.8v 1539.495n 1.8v 1539.505n 1.8v 1549.495n 1.8v 1549.505n 1.8v 1559.495n 1.8v 1559.505n 1.8v 1569.495n 1.8v 1569.505n 1.8v 1579.495n 1.8v 1579.505n 1.8v 1589.495n 1.8v 1589.505n 0.0v 1599.495n 0.0v 1599.505n 0.0v 1609.495n 0.0v 1609.505n 0.0v 1619.495n 0.0v 1619.505n 0.0v 1629.495n 0.0v 1629.505n 0.0v 1639.495n 0.0v 1639.505n 0.0v 1649.495n 0.0v 1649.505n 0.0v 1659.495n 0.0v 1659.505n 0.0v 1669.495n 0.0v 1669.505n 1.8v 1679.495n 1.8v 1679.505n 1.8v 1689.495n 1.8v 1689.505n 1.8v 1699.495n 1.8v 1699.505n 1.8v 1709.495n 1.8v 1709.505n 1.8v 1719.495n 1.8v 1719.505n 1.8v 1729.495n 1.8v 1729.505n 1.8v 1739.495n 1.8v 1739.505n 0.0v 1749.495n 0.0v 1749.505n 0.0v 1759.495n 0.0v 1759.505n 0.0v 1769.495n 0.0v 1769.505n 0.0v 1779.495n 0.0v 1779.505n 0.0v 1789.495n 0.0v 1789.505n 0.0v 1799.495n 0.0v 1799.505n 0.0v 1809.495n 0.0v 1809.505n 0.0v 1819.495n 0.0v 1819.505n 1.8v 1829.495n 1.8v 1829.505n 1.8v 1839.495n 1.8v 1839.505n 1.8v 1849.495n 1.8v 1849.505n 0.0v 1859.495n 0.0v 1859.505n 0.0v 1869.495n 0.0v 1869.505n 0.0v 1879.495n 0.0v 1879.505n 0.0v 1889.495n 0.0v 1889.505n 0.0v 1899.495n 0.0v 1899.505n 1.8v 1909.495n 1.8v 1909.505n 1.8v 1919.495n 1.8v 1919.505n 1.8v 1929.495n 1.8v 1929.505n 0.0v 1939.495n 0.0v 1939.505n 0.0v 1949.495n 0.0v 1949.505n 0.0v 1959.495n 0.0v 1959.505n 1.8v 1969.495n 1.8v 1969.505n 1.8v 1979.495n 1.8v 1979.505n 1.8v 1989.495n 1.8v 1989.505n 1.8v 1999.495n 1.8v 1999.505n 1.8v 2009.495n 1.8v 2009.505n 1.8v 2019.495n 1.8v 2019.505n 1.8v 2029.495n 1.8v 2029.505n 1.8v 2039.495n 1.8v 2039.505n 0.0v 2049.495n 0.0v 2049.505n 0.0v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)
* PULSE: period=10
Vclk1 clk1 0 PULSE (0 1.8 9.995n 0.01n 0.01n 4.99n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 1.8 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 1.8 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 0 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 50
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=50.05n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 50
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=50.05n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 50
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=50.05n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 50
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=50.05n

* CHECK dout0_12 Vdout0_12ck4 = 1.8 time = 50
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=50.05n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 50
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=50.05n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 50
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=50.05n

* CHECK dout0_15 Vdout0_15ck4 = 1.8 time = 50
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=50.05n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 50
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=50.05n

* CHECK dout0_17 Vdout0_17ck4 = 1.8 time = 50
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=50.05n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 50
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=50.05n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 50
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=50.05n

* CHECK dout0_20 Vdout0_20ck4 = 0 time = 50
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=50.05n

* CHECK dout0_21 Vdout0_21ck4 = 1.8 time = 50
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=50.05n

* CHECK dout0_22 Vdout0_22ck4 = 1.8 time = 50
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=50.05n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 50
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=50.05n

* CHECK dout0_24 Vdout0_24ck4 = 1.8 time = 50
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=50.05n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 50
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=50.05n

* CHECK dout0_26 Vdout0_26ck4 = 1.8 time = 50
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=50.05n

* CHECK dout0_27 Vdout0_27ck4 = 1.8 time = 50
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=50.05n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 50
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=50.05n

* CHECK dout0_29 Vdout0_29ck4 = 1.8 time = 50
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=50.05n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 50
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=50.05n

* CHECK dout0_31 Vdout0_31ck4 = 1.8 time = 50
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=50.05n

* CHECK dout1_0 Vdout1_0ck4 = 1.8 time = 50
.meas tran vdout1_0ck4 FIND v(dout1_0) AT=50.05n

* CHECK dout1_1 Vdout1_1ck4 = 0 time = 50
.meas tran vdout1_1ck4 FIND v(dout1_1) AT=50.05n

* CHECK dout1_2 Vdout1_2ck4 = 1.8 time = 50
.meas tran vdout1_2ck4 FIND v(dout1_2) AT=50.05n

* CHECK dout1_3 Vdout1_3ck4 = 0 time = 50
.meas tran vdout1_3ck4 FIND v(dout1_3) AT=50.05n

* CHECK dout1_4 Vdout1_4ck4 = 0 time = 50
.meas tran vdout1_4ck4 FIND v(dout1_4) AT=50.05n

* CHECK dout1_5 Vdout1_5ck4 = 0 time = 50
.meas tran vdout1_5ck4 FIND v(dout1_5) AT=50.05n

* CHECK dout1_6 Vdout1_6ck4 = 1.8 time = 50
.meas tran vdout1_6ck4 FIND v(dout1_6) AT=50.05n

* CHECK dout1_7 Vdout1_7ck4 = 1.8 time = 50
.meas tran vdout1_7ck4 FIND v(dout1_7) AT=50.05n

* CHECK dout1_8 Vdout1_8ck4 = 0 time = 50
.meas tran vdout1_8ck4 FIND v(dout1_8) AT=50.05n

* CHECK dout1_9 Vdout1_9ck4 = 1.8 time = 50
.meas tran vdout1_9ck4 FIND v(dout1_9) AT=50.05n

* CHECK dout1_10 Vdout1_10ck4 = 0 time = 50
.meas tran vdout1_10ck4 FIND v(dout1_10) AT=50.05n

* CHECK dout1_11 Vdout1_11ck4 = 1.8 time = 50
.meas tran vdout1_11ck4 FIND v(dout1_11) AT=50.05n

* CHECK dout1_12 Vdout1_12ck4 = 1.8 time = 50
.meas tran vdout1_12ck4 FIND v(dout1_12) AT=50.05n

* CHECK dout1_13 Vdout1_13ck4 = 0 time = 50
.meas tran vdout1_13ck4 FIND v(dout1_13) AT=50.05n

* CHECK dout1_14 Vdout1_14ck4 = 1.8 time = 50
.meas tran vdout1_14ck4 FIND v(dout1_14) AT=50.05n

* CHECK dout1_15 Vdout1_15ck4 = 0 time = 50
.meas tran vdout1_15ck4 FIND v(dout1_15) AT=50.05n

* CHECK dout1_16 Vdout1_16ck4 = 1.8 time = 50
.meas tran vdout1_16ck4 FIND v(dout1_16) AT=50.05n

* CHECK dout1_17 Vdout1_17ck4 = 1.8 time = 50
.meas tran vdout1_17ck4 FIND v(dout1_17) AT=50.05n

* CHECK dout1_18 Vdout1_18ck4 = 1.8 time = 50
.meas tran vdout1_18ck4 FIND v(dout1_18) AT=50.05n

* CHECK dout1_19 Vdout1_19ck4 = 0 time = 50
.meas tran vdout1_19ck4 FIND v(dout1_19) AT=50.05n

* CHECK dout1_20 Vdout1_20ck4 = 0 time = 50
.meas tran vdout1_20ck4 FIND v(dout1_20) AT=50.05n

* CHECK dout1_21 Vdout1_21ck4 = 1.8 time = 50
.meas tran vdout1_21ck4 FIND v(dout1_21) AT=50.05n

* CHECK dout1_22 Vdout1_22ck4 = 0 time = 50
.meas tran vdout1_22ck4 FIND v(dout1_22) AT=50.05n

* CHECK dout1_23 Vdout1_23ck4 = 1.8 time = 50
.meas tran vdout1_23ck4 FIND v(dout1_23) AT=50.05n

* CHECK dout1_24 Vdout1_24ck4 = 1.8 time = 50
.meas tran vdout1_24ck4 FIND v(dout1_24) AT=50.05n

* CHECK dout1_25 Vdout1_25ck4 = 0 time = 50
.meas tran vdout1_25ck4 FIND v(dout1_25) AT=50.05n

* CHECK dout1_26 Vdout1_26ck4 = 0 time = 50
.meas tran vdout1_26ck4 FIND v(dout1_26) AT=50.05n

* CHECK dout1_27 Vdout1_27ck4 = 1.8 time = 50
.meas tran vdout1_27ck4 FIND v(dout1_27) AT=50.05n

* CHECK dout1_28 Vdout1_28ck4 = 1.8 time = 50
.meas tran vdout1_28ck4 FIND v(dout1_28) AT=50.05n

* CHECK dout1_29 Vdout1_29ck4 = 1.8 time = 50
.meas tran vdout1_29ck4 FIND v(dout1_29) AT=50.05n

* CHECK dout1_30 Vdout1_30ck4 = 0 time = 50
.meas tran vdout1_30ck4 FIND v(dout1_30) AT=50.05n

* CHECK dout1_31 Vdout1_31ck4 = 0 time = 50
.meas tran vdout1_31ck4 FIND v(dout1_31) AT=50.05n

* CHECK dout1_0 Vdout1_0ck6 = 1.8 time = 70
.meas tran vdout1_0ck6 FIND v(dout1_0) AT=70.05n

* CHECK dout1_1 Vdout1_1ck6 = 0 time = 70
.meas tran vdout1_1ck6 FIND v(dout1_1) AT=70.05n

* CHECK dout1_2 Vdout1_2ck6 = 1.8 time = 70
.meas tran vdout1_2ck6 FIND v(dout1_2) AT=70.05n

* CHECK dout1_3 Vdout1_3ck6 = 0 time = 70
.meas tran vdout1_3ck6 FIND v(dout1_3) AT=70.05n

* CHECK dout1_4 Vdout1_4ck6 = 0 time = 70
.meas tran vdout1_4ck6 FIND v(dout1_4) AT=70.05n

* CHECK dout1_5 Vdout1_5ck6 = 0 time = 70
.meas tran vdout1_5ck6 FIND v(dout1_5) AT=70.05n

* CHECK dout1_6 Vdout1_6ck6 = 1.8 time = 70
.meas tran vdout1_6ck6 FIND v(dout1_6) AT=70.05n

* CHECK dout1_7 Vdout1_7ck6 = 1.8 time = 70
.meas tran vdout1_7ck6 FIND v(dout1_7) AT=70.05n

* CHECK dout1_8 Vdout1_8ck6 = 1.8 time = 70
.meas tran vdout1_8ck6 FIND v(dout1_8) AT=70.05n

* CHECK dout1_9 Vdout1_9ck6 = 0 time = 70
.meas tran vdout1_9ck6 FIND v(dout1_9) AT=70.05n

* CHECK dout1_10 Vdout1_10ck6 = 1.8 time = 70
.meas tran vdout1_10ck6 FIND v(dout1_10) AT=70.05n

* CHECK dout1_11 Vdout1_11ck6 = 1.8 time = 70
.meas tran vdout1_11ck6 FIND v(dout1_11) AT=70.05n

* CHECK dout1_12 Vdout1_12ck6 = 1.8 time = 70
.meas tran vdout1_12ck6 FIND v(dout1_12) AT=70.05n

* CHECK dout1_13 Vdout1_13ck6 = 0 time = 70
.meas tran vdout1_13ck6 FIND v(dout1_13) AT=70.05n

* CHECK dout1_14 Vdout1_14ck6 = 1.8 time = 70
.meas tran vdout1_14ck6 FIND v(dout1_14) AT=70.05n

* CHECK dout1_15 Vdout1_15ck6 = 1.8 time = 70
.meas tran vdout1_15ck6 FIND v(dout1_15) AT=70.05n

* CHECK dout1_16 Vdout1_16ck6 = 0 time = 70
.meas tran vdout1_16ck6 FIND v(dout1_16) AT=70.05n

* CHECK dout1_17 Vdout1_17ck6 = 0 time = 70
.meas tran vdout1_17ck6 FIND v(dout1_17) AT=70.05n

* CHECK dout1_18 Vdout1_18ck6 = 0 time = 70
.meas tran vdout1_18ck6 FIND v(dout1_18) AT=70.05n

* CHECK dout1_19 Vdout1_19ck6 = 0 time = 70
.meas tran vdout1_19ck6 FIND v(dout1_19) AT=70.05n

* CHECK dout1_20 Vdout1_20ck6 = 1.8 time = 70
.meas tran vdout1_20ck6 FIND v(dout1_20) AT=70.05n

* CHECK dout1_21 Vdout1_21ck6 = 0 time = 70
.meas tran vdout1_21ck6 FIND v(dout1_21) AT=70.05n

* CHECK dout1_22 Vdout1_22ck6 = 0 time = 70
.meas tran vdout1_22ck6 FIND v(dout1_22) AT=70.05n

* CHECK dout1_23 Vdout1_23ck6 = 0 time = 70
.meas tran vdout1_23ck6 FIND v(dout1_23) AT=70.05n

* CHECK dout1_24 Vdout1_24ck6 = 0 time = 70
.meas tran vdout1_24ck6 FIND v(dout1_24) AT=70.05n

* CHECK dout1_25 Vdout1_25ck6 = 0 time = 70
.meas tran vdout1_25ck6 FIND v(dout1_25) AT=70.05n

* CHECK dout1_26 Vdout1_26ck6 = 1.8 time = 70
.meas tran vdout1_26ck6 FIND v(dout1_26) AT=70.05n

* CHECK dout1_27 Vdout1_27ck6 = 1.8 time = 70
.meas tran vdout1_27ck6 FIND v(dout1_27) AT=70.05n

* CHECK dout1_28 Vdout1_28ck6 = 1.8 time = 70
.meas tran vdout1_28ck6 FIND v(dout1_28) AT=70.05n

* CHECK dout1_29 Vdout1_29ck6 = 0 time = 70
.meas tran vdout1_29ck6 FIND v(dout1_29) AT=70.05n

* CHECK dout1_30 Vdout1_30ck6 = 0 time = 70
.meas tran vdout1_30ck6 FIND v(dout1_30) AT=70.05n

* CHECK dout1_31 Vdout1_31ck6 = 1.8 time = 70
.meas tran vdout1_31ck6 FIND v(dout1_31) AT=70.05n

* CHECK dout1_0 Vdout1_0ck8 = 1.8 time = 90
.meas tran vdout1_0ck8 FIND v(dout1_0) AT=90.05n

* CHECK dout1_1 Vdout1_1ck8 = 0 time = 90
.meas tran vdout1_1ck8 FIND v(dout1_1) AT=90.05n

* CHECK dout1_2 Vdout1_2ck8 = 0 time = 90
.meas tran vdout1_2ck8 FIND v(dout1_2) AT=90.05n

* CHECK dout1_3 Vdout1_3ck8 = 1.8 time = 90
.meas tran vdout1_3ck8 FIND v(dout1_3) AT=90.05n

* CHECK dout1_4 Vdout1_4ck8 = 1.8 time = 90
.meas tran vdout1_4ck8 FIND v(dout1_4) AT=90.05n

* CHECK dout1_5 Vdout1_5ck8 = 0 time = 90
.meas tran vdout1_5ck8 FIND v(dout1_5) AT=90.05n

* CHECK dout1_6 Vdout1_6ck8 = 0 time = 90
.meas tran vdout1_6ck8 FIND v(dout1_6) AT=90.05n

* CHECK dout1_7 Vdout1_7ck8 = 1.8 time = 90
.meas tran vdout1_7ck8 FIND v(dout1_7) AT=90.05n

* CHECK dout1_8 Vdout1_8ck8 = 0 time = 90
.meas tran vdout1_8ck8 FIND v(dout1_8) AT=90.05n

* CHECK dout1_9 Vdout1_9ck8 = 0 time = 90
.meas tran vdout1_9ck8 FIND v(dout1_9) AT=90.05n

* CHECK dout1_10 Vdout1_10ck8 = 0 time = 90
.meas tran vdout1_10ck8 FIND v(dout1_10) AT=90.05n

* CHECK dout1_11 Vdout1_11ck8 = 1.8 time = 90
.meas tran vdout1_11ck8 FIND v(dout1_11) AT=90.05n

* CHECK dout1_12 Vdout1_12ck8 = 1.8 time = 90
.meas tran vdout1_12ck8 FIND v(dout1_12) AT=90.05n

* CHECK dout1_13 Vdout1_13ck8 = 0 time = 90
.meas tran vdout1_13ck8 FIND v(dout1_13) AT=90.05n

* CHECK dout1_14 Vdout1_14ck8 = 0 time = 90
.meas tran vdout1_14ck8 FIND v(dout1_14) AT=90.05n

* CHECK dout1_15 Vdout1_15ck8 = 1.8 time = 90
.meas tran vdout1_15ck8 FIND v(dout1_15) AT=90.05n

* CHECK dout1_16 Vdout1_16ck8 = 0 time = 90
.meas tran vdout1_16ck8 FIND v(dout1_16) AT=90.05n

* CHECK dout1_17 Vdout1_17ck8 = 1.8 time = 90
.meas tran vdout1_17ck8 FIND v(dout1_17) AT=90.05n

* CHECK dout1_18 Vdout1_18ck8 = 0 time = 90
.meas tran vdout1_18ck8 FIND v(dout1_18) AT=90.05n

* CHECK dout1_19 Vdout1_19ck8 = 0 time = 90
.meas tran vdout1_19ck8 FIND v(dout1_19) AT=90.05n

* CHECK dout1_20 Vdout1_20ck8 = 0 time = 90
.meas tran vdout1_20ck8 FIND v(dout1_20) AT=90.05n

* CHECK dout1_21 Vdout1_21ck8 = 1.8 time = 90
.meas tran vdout1_21ck8 FIND v(dout1_21) AT=90.05n

* CHECK dout1_22 Vdout1_22ck8 = 1.8 time = 90
.meas tran vdout1_22ck8 FIND v(dout1_22) AT=90.05n

* CHECK dout1_23 Vdout1_23ck8 = 0 time = 90
.meas tran vdout1_23ck8 FIND v(dout1_23) AT=90.05n

* CHECK dout1_24 Vdout1_24ck8 = 0 time = 90
.meas tran vdout1_24ck8 FIND v(dout1_24) AT=90.05n

* CHECK dout1_25 Vdout1_25ck8 = 0 time = 90
.meas tran vdout1_25ck8 FIND v(dout1_25) AT=90.05n

* CHECK dout1_26 Vdout1_26ck8 = 0 time = 90
.meas tran vdout1_26ck8 FIND v(dout1_26) AT=90.05n

* CHECK dout1_27 Vdout1_27ck8 = 0 time = 90
.meas tran vdout1_27ck8 FIND v(dout1_27) AT=90.05n

* CHECK dout1_28 Vdout1_28ck8 = 1.8 time = 90
.meas tran vdout1_28ck8 FIND v(dout1_28) AT=90.05n

* CHECK dout1_29 Vdout1_29ck8 = 1.8 time = 90
.meas tran vdout1_29ck8 FIND v(dout1_29) AT=90.05n

* CHECK dout1_30 Vdout1_30ck8 = 0 time = 90
.meas tran vdout1_30ck8 FIND v(dout1_30) AT=90.05n

* CHECK dout1_31 Vdout1_31ck8 = 1.8 time = 90
.meas tran vdout1_31ck8 FIND v(dout1_31) AT=90.05n

* CHECK dout1_0 Vdout1_0ck10 = 1.8 time = 110
.meas tran vdout1_0ck10 FIND v(dout1_0) AT=110.05n

* CHECK dout1_1 Vdout1_1ck10 = 0 time = 110
.meas tran vdout1_1ck10 FIND v(dout1_1) AT=110.05n

* CHECK dout1_2 Vdout1_2ck10 = 0 time = 110
.meas tran vdout1_2ck10 FIND v(dout1_2) AT=110.05n

* CHECK dout1_3 Vdout1_3ck10 = 1.8 time = 110
.meas tran vdout1_3ck10 FIND v(dout1_3) AT=110.05n

* CHECK dout1_4 Vdout1_4ck10 = 1.8 time = 110
.meas tran vdout1_4ck10 FIND v(dout1_4) AT=110.05n

* CHECK dout1_5 Vdout1_5ck10 = 0 time = 110
.meas tran vdout1_5ck10 FIND v(dout1_5) AT=110.05n

* CHECK dout1_6 Vdout1_6ck10 = 0 time = 110
.meas tran vdout1_6ck10 FIND v(dout1_6) AT=110.05n

* CHECK dout1_7 Vdout1_7ck10 = 1.8 time = 110
.meas tran vdout1_7ck10 FIND v(dout1_7) AT=110.05n

* CHECK dout1_8 Vdout1_8ck10 = 0 time = 110
.meas tran vdout1_8ck10 FIND v(dout1_8) AT=110.05n

* CHECK dout1_9 Vdout1_9ck10 = 0 time = 110
.meas tran vdout1_9ck10 FIND v(dout1_9) AT=110.05n

* CHECK dout1_10 Vdout1_10ck10 = 0 time = 110
.meas tran vdout1_10ck10 FIND v(dout1_10) AT=110.05n

* CHECK dout1_11 Vdout1_11ck10 = 1.8 time = 110
.meas tran vdout1_11ck10 FIND v(dout1_11) AT=110.05n

* CHECK dout1_12 Vdout1_12ck10 = 1.8 time = 110
.meas tran vdout1_12ck10 FIND v(dout1_12) AT=110.05n

* CHECK dout1_13 Vdout1_13ck10 = 0 time = 110
.meas tran vdout1_13ck10 FIND v(dout1_13) AT=110.05n

* CHECK dout1_14 Vdout1_14ck10 = 0 time = 110
.meas tran vdout1_14ck10 FIND v(dout1_14) AT=110.05n

* CHECK dout1_15 Vdout1_15ck10 = 1.8 time = 110
.meas tran vdout1_15ck10 FIND v(dout1_15) AT=110.05n

* CHECK dout1_16 Vdout1_16ck10 = 0 time = 110
.meas tran vdout1_16ck10 FIND v(dout1_16) AT=110.05n

* CHECK dout1_17 Vdout1_17ck10 = 1.8 time = 110
.meas tran vdout1_17ck10 FIND v(dout1_17) AT=110.05n

* CHECK dout1_18 Vdout1_18ck10 = 0 time = 110
.meas tran vdout1_18ck10 FIND v(dout1_18) AT=110.05n

* CHECK dout1_19 Vdout1_19ck10 = 0 time = 110
.meas tran vdout1_19ck10 FIND v(dout1_19) AT=110.05n

* CHECK dout1_20 Vdout1_20ck10 = 0 time = 110
.meas tran vdout1_20ck10 FIND v(dout1_20) AT=110.05n

* CHECK dout1_21 Vdout1_21ck10 = 1.8 time = 110
.meas tran vdout1_21ck10 FIND v(dout1_21) AT=110.05n

* CHECK dout1_22 Vdout1_22ck10 = 1.8 time = 110
.meas tran vdout1_22ck10 FIND v(dout1_22) AT=110.05n

* CHECK dout1_23 Vdout1_23ck10 = 0 time = 110
.meas tran vdout1_23ck10 FIND v(dout1_23) AT=110.05n

* CHECK dout1_24 Vdout1_24ck10 = 0 time = 110
.meas tran vdout1_24ck10 FIND v(dout1_24) AT=110.05n

* CHECK dout1_25 Vdout1_25ck10 = 0 time = 110
.meas tran vdout1_25ck10 FIND v(dout1_25) AT=110.05n

* CHECK dout1_26 Vdout1_26ck10 = 0 time = 110
.meas tran vdout1_26ck10 FIND v(dout1_26) AT=110.05n

* CHECK dout1_27 Vdout1_27ck10 = 0 time = 110
.meas tran vdout1_27ck10 FIND v(dout1_27) AT=110.05n

* CHECK dout1_28 Vdout1_28ck10 = 1.8 time = 110
.meas tran vdout1_28ck10 FIND v(dout1_28) AT=110.05n

* CHECK dout1_29 Vdout1_29ck10 = 1.8 time = 110
.meas tran vdout1_29ck10 FIND v(dout1_29) AT=110.05n

* CHECK dout1_30 Vdout1_30ck10 = 0 time = 110
.meas tran vdout1_30ck10 FIND v(dout1_30) AT=110.05n

* CHECK dout1_31 Vdout1_31ck10 = 1.8 time = 110
.meas tran vdout1_31ck10 FIND v(dout1_31) AT=110.05n

* CHECK dout0_0 Vdout0_0ck12 = 0 time = 130
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=130.05n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 130
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=130.05n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 130
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=130.05n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 130
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=130.05n

* CHECK dout0_4 Vdout0_4ck12 = 1.8 time = 130
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=130.05n

* CHECK dout0_5 Vdout0_5ck12 = 1.8 time = 130
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=130.05n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 130
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=130.05n

* CHECK dout0_7 Vdout0_7ck12 = 1.8 time = 130
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=130.05n

* CHECK dout0_8 Vdout0_8ck12 = 1.8 time = 130
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=130.05n

* CHECK dout0_9 Vdout0_9ck12 = 1.8 time = 130
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=130.05n

* CHECK dout0_10 Vdout0_10ck12 = 1.8 time = 130
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=130.05n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 130
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=130.05n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 130
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=130.05n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 130
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=130.05n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 130
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=130.05n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 130
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=130.05n

* CHECK dout0_16 Vdout0_16ck12 = 1.8 time = 130
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=130.05n

* CHECK dout0_17 Vdout0_17ck12 = 1.8 time = 130
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=130.05n

* CHECK dout0_18 Vdout0_18ck12 = 1.8 time = 130
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=130.05n

* CHECK dout0_19 Vdout0_19ck12 = 1.8 time = 130
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=130.05n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 130
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=130.05n

* CHECK dout0_21 Vdout0_21ck12 = 0 time = 130
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=130.05n

* CHECK dout0_22 Vdout0_22ck12 = 1.8 time = 130
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=130.05n

* CHECK dout0_23 Vdout0_23ck12 = 0 time = 130
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=130.05n

* CHECK dout0_24 Vdout0_24ck12 = 0 time = 130
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=130.05n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 130
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=130.05n

* CHECK dout0_26 Vdout0_26ck12 = 1.8 time = 130
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=130.05n

* CHECK dout0_27 Vdout0_27ck12 = 1.8 time = 130
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=130.05n

* CHECK dout0_28 Vdout0_28ck12 = 1.8 time = 130
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=130.05n

* CHECK dout0_29 Vdout0_29ck12 = 0 time = 130
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=130.05n

* CHECK dout0_30 Vdout0_30ck12 = 1.8 time = 130
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=130.05n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 130
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=130.05n

* CHECK dout0_0 Vdout0_0ck14 = 0 time = 150
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=150.05n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 150
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=150.05n

* CHECK dout0_2 Vdout0_2ck14 = 0 time = 150
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=150.05n

* CHECK dout0_3 Vdout0_3ck14 = 0 time = 150
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=150.05n

* CHECK dout0_4 Vdout0_4ck14 = 1.8 time = 150
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=150.05n

* CHECK dout0_5 Vdout0_5ck14 = 1.8 time = 150
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=150.05n

* CHECK dout0_6 Vdout0_6ck14 = 0 time = 150
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=150.05n

* CHECK dout0_7 Vdout0_7ck14 = 1.8 time = 150
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=150.05n

* CHECK dout0_8 Vdout0_8ck14 = 1.8 time = 150
.meas tran vdout0_8ck14 FIND v(dout0_8) AT=150.05n

* CHECK dout0_9 Vdout0_9ck14 = 1.8 time = 150
.meas tran vdout0_9ck14 FIND v(dout0_9) AT=150.05n

* CHECK dout0_10 Vdout0_10ck14 = 1.8 time = 150
.meas tran vdout0_10ck14 FIND v(dout0_10) AT=150.05n

* CHECK dout0_11 Vdout0_11ck14 = 0 time = 150
.meas tran vdout0_11ck14 FIND v(dout0_11) AT=150.05n

* CHECK dout0_12 Vdout0_12ck14 = 1.8 time = 150
.meas tran vdout0_12ck14 FIND v(dout0_12) AT=150.05n

* CHECK dout0_13 Vdout0_13ck14 = 0 time = 150
.meas tran vdout0_13ck14 FIND v(dout0_13) AT=150.05n

* CHECK dout0_14 Vdout0_14ck14 = 0 time = 150
.meas tran vdout0_14ck14 FIND v(dout0_14) AT=150.05n

* CHECK dout0_15 Vdout0_15ck14 = 0 time = 150
.meas tran vdout0_15ck14 FIND v(dout0_15) AT=150.05n

* CHECK dout0_16 Vdout0_16ck14 = 1.8 time = 150
.meas tran vdout0_16ck14 FIND v(dout0_16) AT=150.05n

* CHECK dout0_17 Vdout0_17ck14 = 1.8 time = 150
.meas tran vdout0_17ck14 FIND v(dout0_17) AT=150.05n

* CHECK dout0_18 Vdout0_18ck14 = 1.8 time = 150
.meas tran vdout0_18ck14 FIND v(dout0_18) AT=150.05n

* CHECK dout0_19 Vdout0_19ck14 = 1.8 time = 150
.meas tran vdout0_19ck14 FIND v(dout0_19) AT=150.05n

* CHECK dout0_20 Vdout0_20ck14 = 0 time = 150
.meas tran vdout0_20ck14 FIND v(dout0_20) AT=150.05n

* CHECK dout0_21 Vdout0_21ck14 = 0 time = 150
.meas tran vdout0_21ck14 FIND v(dout0_21) AT=150.05n

* CHECK dout0_22 Vdout0_22ck14 = 1.8 time = 150
.meas tran vdout0_22ck14 FIND v(dout0_22) AT=150.05n

* CHECK dout0_23 Vdout0_23ck14 = 0 time = 150
.meas tran vdout0_23ck14 FIND v(dout0_23) AT=150.05n

* CHECK dout0_24 Vdout0_24ck14 = 0 time = 150
.meas tran vdout0_24ck14 FIND v(dout0_24) AT=150.05n

* CHECK dout0_25 Vdout0_25ck14 = 0 time = 150
.meas tran vdout0_25ck14 FIND v(dout0_25) AT=150.05n

* CHECK dout0_26 Vdout0_26ck14 = 1.8 time = 150
.meas tran vdout0_26ck14 FIND v(dout0_26) AT=150.05n

* CHECK dout0_27 Vdout0_27ck14 = 1.8 time = 150
.meas tran vdout0_27ck14 FIND v(dout0_27) AT=150.05n

* CHECK dout0_28 Vdout0_28ck14 = 1.8 time = 150
.meas tran vdout0_28ck14 FIND v(dout0_28) AT=150.05n

* CHECK dout0_29 Vdout0_29ck14 = 0 time = 150
.meas tran vdout0_29ck14 FIND v(dout0_29) AT=150.05n

* CHECK dout0_30 Vdout0_30ck14 = 1.8 time = 150
.meas tran vdout0_30ck14 FIND v(dout0_30) AT=150.05n

* CHECK dout0_31 Vdout0_31ck14 = 0 time = 150
.meas tran vdout0_31ck14 FIND v(dout0_31) AT=150.05n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 180
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=180.05n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 180
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=180.05n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 180
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=180.05n

* CHECK dout0_3 Vdout0_3ck17 = 1.8 time = 180
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=180.05n

* CHECK dout0_4 Vdout0_4ck17 = 1.8 time = 180
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=180.05n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 180
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=180.05n

* CHECK dout0_6 Vdout0_6ck17 = 1.8 time = 180
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=180.05n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 180
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=180.05n

* CHECK dout0_8 Vdout0_8ck17 = 0 time = 180
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=180.05n

* CHECK dout0_9 Vdout0_9ck17 = 0 time = 180
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=180.05n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 180
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=180.05n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 180
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=180.05n

* CHECK dout0_12 Vdout0_12ck17 = 1.8 time = 180
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=180.05n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 180
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=180.05n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 180
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=180.05n

* CHECK dout0_15 Vdout0_15ck17 = 1.8 time = 180
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=180.05n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 180
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=180.05n

* CHECK dout0_17 Vdout0_17ck17 = 0 time = 180
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=180.05n

* CHECK dout0_18 Vdout0_18ck17 = 0 time = 180
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=180.05n

* CHECK dout0_19 Vdout0_19ck17 = 0 time = 180
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=180.05n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 180
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=180.05n

* CHECK dout0_21 Vdout0_21ck17 = 1.8 time = 180
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=180.05n

* CHECK dout0_22 Vdout0_22ck17 = 0 time = 180
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=180.05n

* CHECK dout0_23 Vdout0_23ck17 = 0 time = 180
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=180.05n

* CHECK dout0_24 Vdout0_24ck17 = 1.8 time = 180
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=180.05n

* CHECK dout0_25 Vdout0_25ck17 = 0 time = 180
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=180.05n

* CHECK dout0_26 Vdout0_26ck17 = 1.8 time = 180
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=180.05n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 180
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=180.05n

* CHECK dout0_28 Vdout0_28ck17 = 1.8 time = 180
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=180.05n

* CHECK dout0_29 Vdout0_29ck17 = 1.8 time = 180
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=180.05n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 180
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=180.05n

* CHECK dout0_31 Vdout0_31ck17 = 0 time = 180
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=180.05n

* CHECK dout0_0 Vdout0_0ck19 = 1.8 time = 200
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=200.05n

* CHECK dout0_1 Vdout0_1ck19 = 0 time = 200
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=200.05n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 200
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=200.05n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 200
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=200.05n

* CHECK dout0_4 Vdout0_4ck19 = 1.8 time = 200
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=200.05n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 200
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=200.05n

* CHECK dout0_6 Vdout0_6ck19 = 1.8 time = 200
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=200.05n

* CHECK dout0_7 Vdout0_7ck19 = 1.8 time = 200
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=200.05n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 200
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=200.05n

* CHECK dout0_9 Vdout0_9ck19 = 0 time = 200
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=200.05n

* CHECK dout0_10 Vdout0_10ck19 = 0 time = 200
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=200.05n

* CHECK dout0_11 Vdout0_11ck19 = 1.8 time = 200
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=200.05n

* CHECK dout0_12 Vdout0_12ck19 = 1.8 time = 200
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=200.05n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 200
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=200.05n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 200
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=200.05n

* CHECK dout0_15 Vdout0_15ck19 = 1.8 time = 200
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=200.05n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 200
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=200.05n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 200
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=200.05n

* CHECK dout0_18 Vdout0_18ck19 = 1.8 time = 200
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=200.05n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 200
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=200.05n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 200
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=200.05n

* CHECK dout0_21 Vdout0_21ck19 = 1.8 time = 200
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=200.05n

* CHECK dout0_22 Vdout0_22ck19 = 1.8 time = 200
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=200.05n

* CHECK dout0_23 Vdout0_23ck19 = 0 time = 200
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=200.05n

* CHECK dout0_24 Vdout0_24ck19 = 1.8 time = 200
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=200.05n

* CHECK dout0_25 Vdout0_25ck19 = 1.8 time = 200
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=200.05n

* CHECK dout0_26 Vdout0_26ck19 = 1.8 time = 200
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=200.05n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 200
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=200.05n

* CHECK dout0_28 Vdout0_28ck19 = 1.8 time = 200
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=200.05n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 200
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=200.05n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 200
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=200.05n

* CHECK dout0_31 Vdout0_31ck19 = 1.8 time = 200
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=200.05n

* CHECK dout0_0 Vdout0_0ck21 = 1.8 time = 220
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=220.05n

* CHECK dout0_1 Vdout0_1ck21 = 0 time = 220
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=220.05n

* CHECK dout0_2 Vdout0_2ck21 = 0 time = 220
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=220.05n

* CHECK dout0_3 Vdout0_3ck21 = 1.8 time = 220
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=220.05n

* CHECK dout0_4 Vdout0_4ck21 = 1.8 time = 220
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=220.05n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 220
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=220.05n

* CHECK dout0_6 Vdout0_6ck21 = 1.8 time = 220
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=220.05n

* CHECK dout0_7 Vdout0_7ck21 = 1.8 time = 220
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=220.05n

* CHECK dout0_8 Vdout0_8ck21 = 0 time = 220
.meas tran vdout0_8ck21 FIND v(dout0_8) AT=220.05n

* CHECK dout0_9 Vdout0_9ck21 = 0 time = 220
.meas tran vdout0_9ck21 FIND v(dout0_9) AT=220.05n

* CHECK dout0_10 Vdout0_10ck21 = 0 time = 220
.meas tran vdout0_10ck21 FIND v(dout0_10) AT=220.05n

* CHECK dout0_11 Vdout0_11ck21 = 1.8 time = 220
.meas tran vdout0_11ck21 FIND v(dout0_11) AT=220.05n

* CHECK dout0_12 Vdout0_12ck21 = 1.8 time = 220
.meas tran vdout0_12ck21 FIND v(dout0_12) AT=220.05n

* CHECK dout0_13 Vdout0_13ck21 = 0 time = 220
.meas tran vdout0_13ck21 FIND v(dout0_13) AT=220.05n

* CHECK dout0_14 Vdout0_14ck21 = 0 time = 220
.meas tran vdout0_14ck21 FIND v(dout0_14) AT=220.05n

* CHECK dout0_15 Vdout0_15ck21 = 1.8 time = 220
.meas tran vdout0_15ck21 FIND v(dout0_15) AT=220.05n

* CHECK dout0_16 Vdout0_16ck21 = 0 time = 220
.meas tran vdout0_16ck21 FIND v(dout0_16) AT=220.05n

* CHECK dout0_17 Vdout0_17ck21 = 0 time = 220
.meas tran vdout0_17ck21 FIND v(dout0_17) AT=220.05n

* CHECK dout0_18 Vdout0_18ck21 = 1.8 time = 220
.meas tran vdout0_18ck21 FIND v(dout0_18) AT=220.05n

* CHECK dout0_19 Vdout0_19ck21 = 0 time = 220
.meas tran vdout0_19ck21 FIND v(dout0_19) AT=220.05n

* CHECK dout0_20 Vdout0_20ck21 = 0 time = 220
.meas tran vdout0_20ck21 FIND v(dout0_20) AT=220.05n

* CHECK dout0_21 Vdout0_21ck21 = 1.8 time = 220
.meas tran vdout0_21ck21 FIND v(dout0_21) AT=220.05n

* CHECK dout0_22 Vdout0_22ck21 = 1.8 time = 220
.meas tran vdout0_22ck21 FIND v(dout0_22) AT=220.05n

* CHECK dout0_23 Vdout0_23ck21 = 0 time = 220
.meas tran vdout0_23ck21 FIND v(dout0_23) AT=220.05n

* CHECK dout0_24 Vdout0_24ck21 = 1.8 time = 220
.meas tran vdout0_24ck21 FIND v(dout0_24) AT=220.05n

* CHECK dout0_25 Vdout0_25ck21 = 1.8 time = 220
.meas tran vdout0_25ck21 FIND v(dout0_25) AT=220.05n

* CHECK dout0_26 Vdout0_26ck21 = 1.8 time = 220
.meas tran vdout0_26ck21 FIND v(dout0_26) AT=220.05n

* CHECK dout0_27 Vdout0_27ck21 = 0 time = 220
.meas tran vdout0_27ck21 FIND v(dout0_27) AT=220.05n

* CHECK dout0_28 Vdout0_28ck21 = 1.8 time = 220
.meas tran vdout0_28ck21 FIND v(dout0_28) AT=220.05n

* CHECK dout0_29 Vdout0_29ck21 = 0 time = 220
.meas tran vdout0_29ck21 FIND v(dout0_29) AT=220.05n

* CHECK dout0_30 Vdout0_30ck21 = 0 time = 220
.meas tran vdout0_30ck21 FIND v(dout0_30) AT=220.05n

* CHECK dout0_31 Vdout0_31ck21 = 1.8 time = 220
.meas tran vdout0_31ck21 FIND v(dout0_31) AT=220.05n

* CHECK dout1_0 Vdout1_0ck22 = 1.8 time = 230
.meas tran vdout1_0ck22 FIND v(dout1_0) AT=230.05n

* CHECK dout1_1 Vdout1_1ck22 = 0 time = 230
.meas tran vdout1_1ck22 FIND v(dout1_1) AT=230.05n

* CHECK dout1_2 Vdout1_2ck22 = 0 time = 230
.meas tran vdout1_2ck22 FIND v(dout1_2) AT=230.05n

* CHECK dout1_3 Vdout1_3ck22 = 1.8 time = 230
.meas tran vdout1_3ck22 FIND v(dout1_3) AT=230.05n

* CHECK dout1_4 Vdout1_4ck22 = 1.8 time = 230
.meas tran vdout1_4ck22 FIND v(dout1_4) AT=230.05n

* CHECK dout1_5 Vdout1_5ck22 = 0 time = 230
.meas tran vdout1_5ck22 FIND v(dout1_5) AT=230.05n

* CHECK dout1_6 Vdout1_6ck22 = 0 time = 230
.meas tran vdout1_6ck22 FIND v(dout1_6) AT=230.05n

* CHECK dout1_7 Vdout1_7ck22 = 1.8 time = 230
.meas tran vdout1_7ck22 FIND v(dout1_7) AT=230.05n

* CHECK dout1_8 Vdout1_8ck22 = 0 time = 230
.meas tran vdout1_8ck22 FIND v(dout1_8) AT=230.05n

* CHECK dout1_9 Vdout1_9ck22 = 0 time = 230
.meas tran vdout1_9ck22 FIND v(dout1_9) AT=230.05n

* CHECK dout1_10 Vdout1_10ck22 = 0 time = 230
.meas tran vdout1_10ck22 FIND v(dout1_10) AT=230.05n

* CHECK dout1_11 Vdout1_11ck22 = 1.8 time = 230
.meas tran vdout1_11ck22 FIND v(dout1_11) AT=230.05n

* CHECK dout1_12 Vdout1_12ck22 = 1.8 time = 230
.meas tran vdout1_12ck22 FIND v(dout1_12) AT=230.05n

* CHECK dout1_13 Vdout1_13ck22 = 0 time = 230
.meas tran vdout1_13ck22 FIND v(dout1_13) AT=230.05n

* CHECK dout1_14 Vdout1_14ck22 = 0 time = 230
.meas tran vdout1_14ck22 FIND v(dout1_14) AT=230.05n

* CHECK dout1_15 Vdout1_15ck22 = 1.8 time = 230
.meas tran vdout1_15ck22 FIND v(dout1_15) AT=230.05n

* CHECK dout1_16 Vdout1_16ck22 = 0 time = 230
.meas tran vdout1_16ck22 FIND v(dout1_16) AT=230.05n

* CHECK dout1_17 Vdout1_17ck22 = 1.8 time = 230
.meas tran vdout1_17ck22 FIND v(dout1_17) AT=230.05n

* CHECK dout1_18 Vdout1_18ck22 = 0 time = 230
.meas tran vdout1_18ck22 FIND v(dout1_18) AT=230.05n

* CHECK dout1_19 Vdout1_19ck22 = 0 time = 230
.meas tran vdout1_19ck22 FIND v(dout1_19) AT=230.05n

* CHECK dout1_20 Vdout1_20ck22 = 0 time = 230
.meas tran vdout1_20ck22 FIND v(dout1_20) AT=230.05n

* CHECK dout1_21 Vdout1_21ck22 = 1.8 time = 230
.meas tran vdout1_21ck22 FIND v(dout1_21) AT=230.05n

* CHECK dout1_22 Vdout1_22ck22 = 1.8 time = 230
.meas tran vdout1_22ck22 FIND v(dout1_22) AT=230.05n

* CHECK dout1_23 Vdout1_23ck22 = 0 time = 230
.meas tran vdout1_23ck22 FIND v(dout1_23) AT=230.05n

* CHECK dout1_24 Vdout1_24ck22 = 0 time = 230
.meas tran vdout1_24ck22 FIND v(dout1_24) AT=230.05n

* CHECK dout1_25 Vdout1_25ck22 = 0 time = 230
.meas tran vdout1_25ck22 FIND v(dout1_25) AT=230.05n

* CHECK dout1_26 Vdout1_26ck22 = 0 time = 230
.meas tran vdout1_26ck22 FIND v(dout1_26) AT=230.05n

* CHECK dout1_27 Vdout1_27ck22 = 0 time = 230
.meas tran vdout1_27ck22 FIND v(dout1_27) AT=230.05n

* CHECK dout1_28 Vdout1_28ck22 = 1.8 time = 230
.meas tran vdout1_28ck22 FIND v(dout1_28) AT=230.05n

* CHECK dout1_29 Vdout1_29ck22 = 1.8 time = 230
.meas tran vdout1_29ck22 FIND v(dout1_29) AT=230.05n

* CHECK dout1_30 Vdout1_30ck22 = 0 time = 230
.meas tran vdout1_30ck22 FIND v(dout1_30) AT=230.05n

* CHECK dout1_31 Vdout1_31ck22 = 1.8 time = 230
.meas tran vdout1_31ck22 FIND v(dout1_31) AT=230.05n

* CHECK dout0_0 Vdout0_0ck23 = 1.8 time = 240
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=240.05n

* CHECK dout0_1 Vdout0_1ck23 = 1.8 time = 240
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=240.05n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 240
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=240.05n

* CHECK dout0_3 Vdout0_3ck23 = 1.8 time = 240
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=240.05n

* CHECK dout0_4 Vdout0_4ck23 = 0 time = 240
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=240.05n

* CHECK dout0_5 Vdout0_5ck23 = 1.8 time = 240
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=240.05n

* CHECK dout0_6 Vdout0_6ck23 = 1.8 time = 240
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=240.05n

* CHECK dout0_7 Vdout0_7ck23 = 1.8 time = 240
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=240.05n

* CHECK dout0_8 Vdout0_8ck23 = 1.8 time = 240
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=240.05n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 240
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=240.05n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 240
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=240.05n

* CHECK dout0_11 Vdout0_11ck23 = 1.8 time = 240
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=240.05n

* CHECK dout0_12 Vdout0_12ck23 = 0 time = 240
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=240.05n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 240
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=240.05n

* CHECK dout0_14 Vdout0_14ck23 = 1.8 time = 240
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=240.05n

* CHECK dout0_15 Vdout0_15ck23 = 1.8 time = 240
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=240.05n

* CHECK dout0_16 Vdout0_16ck23 = 1.8 time = 240
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=240.05n

* CHECK dout0_17 Vdout0_17ck23 = 0 time = 240
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=240.05n

* CHECK dout0_18 Vdout0_18ck23 = 1.8 time = 240
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=240.05n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 240
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=240.05n

* CHECK dout0_20 Vdout0_20ck23 = 0 time = 240
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=240.05n

* CHECK dout0_21 Vdout0_21ck23 = 1.8 time = 240
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=240.05n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 240
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=240.05n

* CHECK dout0_23 Vdout0_23ck23 = 0 time = 240
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=240.05n

* CHECK dout0_24 Vdout0_24ck23 = 1.8 time = 240
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=240.05n

* CHECK dout0_25 Vdout0_25ck23 = 1.8 time = 240
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=240.05n

* CHECK dout0_26 Vdout0_26ck23 = 1.8 time = 240
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=240.05n

* CHECK dout0_27 Vdout0_27ck23 = 1.8 time = 240
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=240.05n

* CHECK dout0_28 Vdout0_28ck23 = 0 time = 240
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=240.05n

* CHECK dout0_29 Vdout0_29ck23 = 1.8 time = 240
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=240.05n

* CHECK dout0_30 Vdout0_30ck23 = 1.8 time = 240
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=240.05n

* CHECK dout0_31 Vdout0_31ck23 = 1.8 time = 240
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=240.05n

* CHECK dout1_0 Vdout1_0ck23 = 0 time = 240
.meas tran vdout1_0ck23 FIND v(dout1_0) AT=240.05n

* CHECK dout1_1 Vdout1_1ck23 = 0 time = 240
.meas tran vdout1_1ck23 FIND v(dout1_1) AT=240.05n

* CHECK dout1_2 Vdout1_2ck23 = 0 time = 240
.meas tran vdout1_2ck23 FIND v(dout1_2) AT=240.05n

* CHECK dout1_3 Vdout1_3ck23 = 1.8 time = 240
.meas tran vdout1_3ck23 FIND v(dout1_3) AT=240.05n

* CHECK dout1_4 Vdout1_4ck23 = 1.8 time = 240
.meas tran vdout1_4ck23 FIND v(dout1_4) AT=240.05n

* CHECK dout1_5 Vdout1_5ck23 = 1.8 time = 240
.meas tran vdout1_5ck23 FIND v(dout1_5) AT=240.05n

* CHECK dout1_6 Vdout1_6ck23 = 0 time = 240
.meas tran vdout1_6ck23 FIND v(dout1_6) AT=240.05n

* CHECK dout1_7 Vdout1_7ck23 = 1.8 time = 240
.meas tran vdout1_7ck23 FIND v(dout1_7) AT=240.05n

* CHECK dout1_8 Vdout1_8ck23 = 0 time = 240
.meas tran vdout1_8ck23 FIND v(dout1_8) AT=240.05n

* CHECK dout1_9 Vdout1_9ck23 = 1.8 time = 240
.meas tran vdout1_9ck23 FIND v(dout1_9) AT=240.05n

* CHECK dout1_10 Vdout1_10ck23 = 1.8 time = 240
.meas tran vdout1_10ck23 FIND v(dout1_10) AT=240.05n

* CHECK dout1_11 Vdout1_11ck23 = 0 time = 240
.meas tran vdout1_11ck23 FIND v(dout1_11) AT=240.05n

* CHECK dout1_12 Vdout1_12ck23 = 1.8 time = 240
.meas tran vdout1_12ck23 FIND v(dout1_12) AT=240.05n

* CHECK dout1_13 Vdout1_13ck23 = 0 time = 240
.meas tran vdout1_13ck23 FIND v(dout1_13) AT=240.05n

* CHECK dout1_14 Vdout1_14ck23 = 0 time = 240
.meas tran vdout1_14ck23 FIND v(dout1_14) AT=240.05n

* CHECK dout1_15 Vdout1_15ck23 = 1.8 time = 240
.meas tran vdout1_15ck23 FIND v(dout1_15) AT=240.05n

* CHECK dout1_16 Vdout1_16ck23 = 1.8 time = 240
.meas tran vdout1_16ck23 FIND v(dout1_16) AT=240.05n

* CHECK dout1_17 Vdout1_17ck23 = 0 time = 240
.meas tran vdout1_17ck23 FIND v(dout1_17) AT=240.05n

* CHECK dout1_18 Vdout1_18ck23 = 0 time = 240
.meas tran vdout1_18ck23 FIND v(dout1_18) AT=240.05n

* CHECK dout1_19 Vdout1_19ck23 = 1.8 time = 240
.meas tran vdout1_19ck23 FIND v(dout1_19) AT=240.05n

* CHECK dout1_20 Vdout1_20ck23 = 0 time = 240
.meas tran vdout1_20ck23 FIND v(dout1_20) AT=240.05n

* CHECK dout1_21 Vdout1_21ck23 = 0 time = 240
.meas tran vdout1_21ck23 FIND v(dout1_21) AT=240.05n

* CHECK dout1_22 Vdout1_22ck23 = 0 time = 240
.meas tran vdout1_22ck23 FIND v(dout1_22) AT=240.05n

* CHECK dout1_23 Vdout1_23ck23 = 1.8 time = 240
.meas tran vdout1_23ck23 FIND v(dout1_23) AT=240.05n

* CHECK dout1_24 Vdout1_24ck23 = 1.8 time = 240
.meas tran vdout1_24ck23 FIND v(dout1_24) AT=240.05n

* CHECK dout1_25 Vdout1_25ck23 = 0 time = 240
.meas tran vdout1_25ck23 FIND v(dout1_25) AT=240.05n

* CHECK dout1_26 Vdout1_26ck23 = 0 time = 240
.meas tran vdout1_26ck23 FIND v(dout1_26) AT=240.05n

* CHECK dout1_27 Vdout1_27ck23 = 1.8 time = 240
.meas tran vdout1_27ck23 FIND v(dout1_27) AT=240.05n

* CHECK dout1_28 Vdout1_28ck23 = 1.8 time = 240
.meas tran vdout1_28ck23 FIND v(dout1_28) AT=240.05n

* CHECK dout1_29 Vdout1_29ck23 = 1.8 time = 240
.meas tran vdout1_29ck23 FIND v(dout1_29) AT=240.05n

* CHECK dout1_30 Vdout1_30ck23 = 1.8 time = 240
.meas tran vdout1_30ck23 FIND v(dout1_30) AT=240.05n

* CHECK dout1_31 Vdout1_31ck23 = 1.8 time = 240
.meas tran vdout1_31ck23 FIND v(dout1_31) AT=240.05n

* CHECK dout1_0 Vdout1_0ck24 = 1.8 time = 250
.meas tran vdout1_0ck24 FIND v(dout1_0) AT=250.05n

* CHECK dout1_1 Vdout1_1ck24 = 1.8 time = 250
.meas tran vdout1_1ck24 FIND v(dout1_1) AT=250.05n

* CHECK dout1_2 Vdout1_2ck24 = 0 time = 250
.meas tran vdout1_2ck24 FIND v(dout1_2) AT=250.05n

* CHECK dout1_3 Vdout1_3ck24 = 1.8 time = 250
.meas tran vdout1_3ck24 FIND v(dout1_3) AT=250.05n

* CHECK dout1_4 Vdout1_4ck24 = 0 time = 250
.meas tran vdout1_4ck24 FIND v(dout1_4) AT=250.05n

* CHECK dout1_5 Vdout1_5ck24 = 1.8 time = 250
.meas tran vdout1_5ck24 FIND v(dout1_5) AT=250.05n

* CHECK dout1_6 Vdout1_6ck24 = 1.8 time = 250
.meas tran vdout1_6ck24 FIND v(dout1_6) AT=250.05n

* CHECK dout1_7 Vdout1_7ck24 = 1.8 time = 250
.meas tran vdout1_7ck24 FIND v(dout1_7) AT=250.05n

* CHECK dout1_8 Vdout1_8ck24 = 1.8 time = 250
.meas tran vdout1_8ck24 FIND v(dout1_8) AT=250.05n

* CHECK dout1_9 Vdout1_9ck24 = 0 time = 250
.meas tran vdout1_9ck24 FIND v(dout1_9) AT=250.05n

* CHECK dout1_10 Vdout1_10ck24 = 0 time = 250
.meas tran vdout1_10ck24 FIND v(dout1_10) AT=250.05n

* CHECK dout1_11 Vdout1_11ck24 = 1.8 time = 250
.meas tran vdout1_11ck24 FIND v(dout1_11) AT=250.05n

* CHECK dout1_12 Vdout1_12ck24 = 0 time = 250
.meas tran vdout1_12ck24 FIND v(dout1_12) AT=250.05n

* CHECK dout1_13 Vdout1_13ck24 = 0 time = 250
.meas tran vdout1_13ck24 FIND v(dout1_13) AT=250.05n

* CHECK dout1_14 Vdout1_14ck24 = 1.8 time = 250
.meas tran vdout1_14ck24 FIND v(dout1_14) AT=250.05n

* CHECK dout1_15 Vdout1_15ck24 = 1.8 time = 250
.meas tran vdout1_15ck24 FIND v(dout1_15) AT=250.05n

* CHECK dout1_16 Vdout1_16ck24 = 1.8 time = 250
.meas tran vdout1_16ck24 FIND v(dout1_16) AT=250.05n

* CHECK dout1_17 Vdout1_17ck24 = 0 time = 250
.meas tran vdout1_17ck24 FIND v(dout1_17) AT=250.05n

* CHECK dout1_18 Vdout1_18ck24 = 1.8 time = 250
.meas tran vdout1_18ck24 FIND v(dout1_18) AT=250.05n

* CHECK dout1_19 Vdout1_19ck24 = 0 time = 250
.meas tran vdout1_19ck24 FIND v(dout1_19) AT=250.05n

* CHECK dout1_20 Vdout1_20ck24 = 0 time = 250
.meas tran vdout1_20ck24 FIND v(dout1_20) AT=250.05n

* CHECK dout1_21 Vdout1_21ck24 = 1.8 time = 250
.meas tran vdout1_21ck24 FIND v(dout1_21) AT=250.05n

* CHECK dout1_22 Vdout1_22ck24 = 0 time = 250
.meas tran vdout1_22ck24 FIND v(dout1_22) AT=250.05n

* CHECK dout1_23 Vdout1_23ck24 = 0 time = 250
.meas tran vdout1_23ck24 FIND v(dout1_23) AT=250.05n

* CHECK dout1_24 Vdout1_24ck24 = 1.8 time = 250
.meas tran vdout1_24ck24 FIND v(dout1_24) AT=250.05n

* CHECK dout1_25 Vdout1_25ck24 = 1.8 time = 250
.meas tran vdout1_25ck24 FIND v(dout1_25) AT=250.05n

* CHECK dout1_26 Vdout1_26ck24 = 1.8 time = 250
.meas tran vdout1_26ck24 FIND v(dout1_26) AT=250.05n

* CHECK dout1_27 Vdout1_27ck24 = 1.8 time = 250
.meas tran vdout1_27ck24 FIND v(dout1_27) AT=250.05n

* CHECK dout1_28 Vdout1_28ck24 = 0 time = 250
.meas tran vdout1_28ck24 FIND v(dout1_28) AT=250.05n

* CHECK dout1_29 Vdout1_29ck24 = 1.8 time = 250
.meas tran vdout1_29ck24 FIND v(dout1_29) AT=250.05n

* CHECK dout1_30 Vdout1_30ck24 = 1.8 time = 250
.meas tran vdout1_30ck24 FIND v(dout1_30) AT=250.05n

* CHECK dout1_31 Vdout1_31ck24 = 1.8 time = 250
.meas tran vdout1_31ck24 FIND v(dout1_31) AT=250.05n

* CHECK dout1_0 Vdout1_0ck25 = 0 time = 260
.meas tran vdout1_0ck25 FIND v(dout1_0) AT=260.05n

* CHECK dout1_1 Vdout1_1ck25 = 0 time = 260
.meas tran vdout1_1ck25 FIND v(dout1_1) AT=260.05n

* CHECK dout1_2 Vdout1_2ck25 = 0 time = 260
.meas tran vdout1_2ck25 FIND v(dout1_2) AT=260.05n

* CHECK dout1_3 Vdout1_3ck25 = 1.8 time = 260
.meas tran vdout1_3ck25 FIND v(dout1_3) AT=260.05n

* CHECK dout1_4 Vdout1_4ck25 = 1.8 time = 260
.meas tran vdout1_4ck25 FIND v(dout1_4) AT=260.05n

* CHECK dout1_5 Vdout1_5ck25 = 1.8 time = 260
.meas tran vdout1_5ck25 FIND v(dout1_5) AT=260.05n

* CHECK dout1_6 Vdout1_6ck25 = 0 time = 260
.meas tran vdout1_6ck25 FIND v(dout1_6) AT=260.05n

* CHECK dout1_7 Vdout1_7ck25 = 1.8 time = 260
.meas tran vdout1_7ck25 FIND v(dout1_7) AT=260.05n

* CHECK dout1_8 Vdout1_8ck25 = 0 time = 260
.meas tran vdout1_8ck25 FIND v(dout1_8) AT=260.05n

* CHECK dout1_9 Vdout1_9ck25 = 1.8 time = 260
.meas tran vdout1_9ck25 FIND v(dout1_9) AT=260.05n

* CHECK dout1_10 Vdout1_10ck25 = 1.8 time = 260
.meas tran vdout1_10ck25 FIND v(dout1_10) AT=260.05n

* CHECK dout1_11 Vdout1_11ck25 = 0 time = 260
.meas tran vdout1_11ck25 FIND v(dout1_11) AT=260.05n

* CHECK dout1_12 Vdout1_12ck25 = 1.8 time = 260
.meas tran vdout1_12ck25 FIND v(dout1_12) AT=260.05n

* CHECK dout1_13 Vdout1_13ck25 = 0 time = 260
.meas tran vdout1_13ck25 FIND v(dout1_13) AT=260.05n

* CHECK dout1_14 Vdout1_14ck25 = 0 time = 260
.meas tran vdout1_14ck25 FIND v(dout1_14) AT=260.05n

* CHECK dout1_15 Vdout1_15ck25 = 1.8 time = 260
.meas tran vdout1_15ck25 FIND v(dout1_15) AT=260.05n

* CHECK dout1_16 Vdout1_16ck25 = 1.8 time = 260
.meas tran vdout1_16ck25 FIND v(dout1_16) AT=260.05n

* CHECK dout1_17 Vdout1_17ck25 = 0 time = 260
.meas tran vdout1_17ck25 FIND v(dout1_17) AT=260.05n

* CHECK dout1_18 Vdout1_18ck25 = 0 time = 260
.meas tran vdout1_18ck25 FIND v(dout1_18) AT=260.05n

* CHECK dout1_19 Vdout1_19ck25 = 1.8 time = 260
.meas tran vdout1_19ck25 FIND v(dout1_19) AT=260.05n

* CHECK dout1_20 Vdout1_20ck25 = 0 time = 260
.meas tran vdout1_20ck25 FIND v(dout1_20) AT=260.05n

* CHECK dout1_21 Vdout1_21ck25 = 0 time = 260
.meas tran vdout1_21ck25 FIND v(dout1_21) AT=260.05n

* CHECK dout1_22 Vdout1_22ck25 = 0 time = 260
.meas tran vdout1_22ck25 FIND v(dout1_22) AT=260.05n

* CHECK dout1_23 Vdout1_23ck25 = 1.8 time = 260
.meas tran vdout1_23ck25 FIND v(dout1_23) AT=260.05n

* CHECK dout1_24 Vdout1_24ck25 = 1.8 time = 260
.meas tran vdout1_24ck25 FIND v(dout1_24) AT=260.05n

* CHECK dout1_25 Vdout1_25ck25 = 0 time = 260
.meas tran vdout1_25ck25 FIND v(dout1_25) AT=260.05n

* CHECK dout1_26 Vdout1_26ck25 = 0 time = 260
.meas tran vdout1_26ck25 FIND v(dout1_26) AT=260.05n

* CHECK dout1_27 Vdout1_27ck25 = 1.8 time = 260
.meas tran vdout1_27ck25 FIND v(dout1_27) AT=260.05n

* CHECK dout1_28 Vdout1_28ck25 = 1.8 time = 260
.meas tran vdout1_28ck25 FIND v(dout1_28) AT=260.05n

* CHECK dout1_29 Vdout1_29ck25 = 1.8 time = 260
.meas tran vdout1_29ck25 FIND v(dout1_29) AT=260.05n

* CHECK dout1_30 Vdout1_30ck25 = 1.8 time = 260
.meas tran vdout1_30ck25 FIND v(dout1_30) AT=260.05n

* CHECK dout1_31 Vdout1_31ck25 = 1.8 time = 260
.meas tran vdout1_31ck25 FIND v(dout1_31) AT=260.05n

* CHECK dout1_0 Vdout1_0ck26 = 0 time = 270
.meas tran vdout1_0ck26 FIND v(dout1_0) AT=270.05n

* CHECK dout1_1 Vdout1_1ck26 = 0 time = 270
.meas tran vdout1_1ck26 FIND v(dout1_1) AT=270.05n

* CHECK dout1_2 Vdout1_2ck26 = 0 time = 270
.meas tran vdout1_2ck26 FIND v(dout1_2) AT=270.05n

* CHECK dout1_3 Vdout1_3ck26 = 1.8 time = 270
.meas tran vdout1_3ck26 FIND v(dout1_3) AT=270.05n

* CHECK dout1_4 Vdout1_4ck26 = 1.8 time = 270
.meas tran vdout1_4ck26 FIND v(dout1_4) AT=270.05n

* CHECK dout1_5 Vdout1_5ck26 = 1.8 time = 270
.meas tran vdout1_5ck26 FIND v(dout1_5) AT=270.05n

* CHECK dout1_6 Vdout1_6ck26 = 0 time = 270
.meas tran vdout1_6ck26 FIND v(dout1_6) AT=270.05n

* CHECK dout1_7 Vdout1_7ck26 = 1.8 time = 270
.meas tran vdout1_7ck26 FIND v(dout1_7) AT=270.05n

* CHECK dout1_8 Vdout1_8ck26 = 0 time = 270
.meas tran vdout1_8ck26 FIND v(dout1_8) AT=270.05n

* CHECK dout1_9 Vdout1_9ck26 = 1.8 time = 270
.meas tran vdout1_9ck26 FIND v(dout1_9) AT=270.05n

* CHECK dout1_10 Vdout1_10ck26 = 1.8 time = 270
.meas tran vdout1_10ck26 FIND v(dout1_10) AT=270.05n

* CHECK dout1_11 Vdout1_11ck26 = 0 time = 270
.meas tran vdout1_11ck26 FIND v(dout1_11) AT=270.05n

* CHECK dout1_12 Vdout1_12ck26 = 1.8 time = 270
.meas tran vdout1_12ck26 FIND v(dout1_12) AT=270.05n

* CHECK dout1_13 Vdout1_13ck26 = 0 time = 270
.meas tran vdout1_13ck26 FIND v(dout1_13) AT=270.05n

* CHECK dout1_14 Vdout1_14ck26 = 0 time = 270
.meas tran vdout1_14ck26 FIND v(dout1_14) AT=270.05n

* CHECK dout1_15 Vdout1_15ck26 = 1.8 time = 270
.meas tran vdout1_15ck26 FIND v(dout1_15) AT=270.05n

* CHECK dout1_16 Vdout1_16ck26 = 1.8 time = 270
.meas tran vdout1_16ck26 FIND v(dout1_16) AT=270.05n

* CHECK dout1_17 Vdout1_17ck26 = 0 time = 270
.meas tran vdout1_17ck26 FIND v(dout1_17) AT=270.05n

* CHECK dout1_18 Vdout1_18ck26 = 0 time = 270
.meas tran vdout1_18ck26 FIND v(dout1_18) AT=270.05n

* CHECK dout1_19 Vdout1_19ck26 = 1.8 time = 270
.meas tran vdout1_19ck26 FIND v(dout1_19) AT=270.05n

* CHECK dout1_20 Vdout1_20ck26 = 0 time = 270
.meas tran vdout1_20ck26 FIND v(dout1_20) AT=270.05n

* CHECK dout1_21 Vdout1_21ck26 = 0 time = 270
.meas tran vdout1_21ck26 FIND v(dout1_21) AT=270.05n

* CHECK dout1_22 Vdout1_22ck26 = 0 time = 270
.meas tran vdout1_22ck26 FIND v(dout1_22) AT=270.05n

* CHECK dout1_23 Vdout1_23ck26 = 1.8 time = 270
.meas tran vdout1_23ck26 FIND v(dout1_23) AT=270.05n

* CHECK dout1_24 Vdout1_24ck26 = 1.8 time = 270
.meas tran vdout1_24ck26 FIND v(dout1_24) AT=270.05n

* CHECK dout1_25 Vdout1_25ck26 = 0 time = 270
.meas tran vdout1_25ck26 FIND v(dout1_25) AT=270.05n

* CHECK dout1_26 Vdout1_26ck26 = 0 time = 270
.meas tran vdout1_26ck26 FIND v(dout1_26) AT=270.05n

* CHECK dout1_27 Vdout1_27ck26 = 1.8 time = 270
.meas tran vdout1_27ck26 FIND v(dout1_27) AT=270.05n

* CHECK dout1_28 Vdout1_28ck26 = 1.8 time = 270
.meas tran vdout1_28ck26 FIND v(dout1_28) AT=270.05n

* CHECK dout1_29 Vdout1_29ck26 = 1.8 time = 270
.meas tran vdout1_29ck26 FIND v(dout1_29) AT=270.05n

* CHECK dout1_30 Vdout1_30ck26 = 1.8 time = 270
.meas tran vdout1_30ck26 FIND v(dout1_30) AT=270.05n

* CHECK dout1_31 Vdout1_31ck26 = 1.8 time = 270
.meas tran vdout1_31ck26 FIND v(dout1_31) AT=270.05n

* CHECK dout0_0 Vdout0_0ck27 = 0 time = 280
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=280.05n

* CHECK dout0_1 Vdout0_1ck27 = 0 time = 280
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=280.05n

* CHECK dout0_2 Vdout0_2ck27 = 0 time = 280
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=280.05n

* CHECK dout0_3 Vdout0_3ck27 = 1.8 time = 280
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=280.05n

* CHECK dout0_4 Vdout0_4ck27 = 1.8 time = 280
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=280.05n

* CHECK dout0_5 Vdout0_5ck27 = 1.8 time = 280
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=280.05n

* CHECK dout0_6 Vdout0_6ck27 = 0 time = 280
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=280.05n

* CHECK dout0_7 Vdout0_7ck27 = 1.8 time = 280
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=280.05n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 280
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=280.05n

* CHECK dout0_9 Vdout0_9ck27 = 1.8 time = 280
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=280.05n

* CHECK dout0_10 Vdout0_10ck27 = 1.8 time = 280
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=280.05n

* CHECK dout0_11 Vdout0_11ck27 = 0 time = 280
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=280.05n

* CHECK dout0_12 Vdout0_12ck27 = 1.8 time = 280
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=280.05n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 280
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=280.05n

* CHECK dout0_14 Vdout0_14ck27 = 0 time = 280
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=280.05n

* CHECK dout0_15 Vdout0_15ck27 = 1.8 time = 280
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=280.05n

* CHECK dout0_16 Vdout0_16ck27 = 1.8 time = 280
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=280.05n

* CHECK dout0_17 Vdout0_17ck27 = 0 time = 280
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=280.05n

* CHECK dout0_18 Vdout0_18ck27 = 0 time = 280
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=280.05n

* CHECK dout0_19 Vdout0_19ck27 = 1.8 time = 280
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=280.05n

* CHECK dout0_20 Vdout0_20ck27 = 0 time = 280
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=280.05n

* CHECK dout0_21 Vdout0_21ck27 = 0 time = 280
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=280.05n

* CHECK dout0_22 Vdout0_22ck27 = 0 time = 280
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=280.05n

* CHECK dout0_23 Vdout0_23ck27 = 1.8 time = 280
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=280.05n

* CHECK dout0_24 Vdout0_24ck27 = 1.8 time = 280
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=280.05n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 280
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=280.05n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 280
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=280.05n

* CHECK dout0_27 Vdout0_27ck27 = 1.8 time = 280
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=280.05n

* CHECK dout0_28 Vdout0_28ck27 = 1.8 time = 280
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=280.05n

* CHECK dout0_29 Vdout0_29ck27 = 1.8 time = 280
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=280.05n

* CHECK dout0_30 Vdout0_30ck27 = 1.8 time = 280
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=280.05n

* CHECK dout0_31 Vdout0_31ck27 = 1.8 time = 280
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=280.05n

* CHECK dout1_0 Vdout1_0ck29 = 0 time = 300
.meas tran vdout1_0ck29 FIND v(dout1_0) AT=300.05n

* CHECK dout1_1 Vdout1_1ck29 = 0 time = 300
.meas tran vdout1_1ck29 FIND v(dout1_1) AT=300.05n

* CHECK dout1_2 Vdout1_2ck29 = 0 time = 300
.meas tran vdout1_2ck29 FIND v(dout1_2) AT=300.05n

* CHECK dout1_3 Vdout1_3ck29 = 1.8 time = 300
.meas tran vdout1_3ck29 FIND v(dout1_3) AT=300.05n

* CHECK dout1_4 Vdout1_4ck29 = 1.8 time = 300
.meas tran vdout1_4ck29 FIND v(dout1_4) AT=300.05n

* CHECK dout1_5 Vdout1_5ck29 = 1.8 time = 300
.meas tran vdout1_5ck29 FIND v(dout1_5) AT=300.05n

* CHECK dout1_6 Vdout1_6ck29 = 0 time = 300
.meas tran vdout1_6ck29 FIND v(dout1_6) AT=300.05n

* CHECK dout1_7 Vdout1_7ck29 = 1.8 time = 300
.meas tran vdout1_7ck29 FIND v(dout1_7) AT=300.05n

* CHECK dout1_8 Vdout1_8ck29 = 0 time = 300
.meas tran vdout1_8ck29 FIND v(dout1_8) AT=300.05n

* CHECK dout1_9 Vdout1_9ck29 = 1.8 time = 300
.meas tran vdout1_9ck29 FIND v(dout1_9) AT=300.05n

* CHECK dout1_10 Vdout1_10ck29 = 1.8 time = 300
.meas tran vdout1_10ck29 FIND v(dout1_10) AT=300.05n

* CHECK dout1_11 Vdout1_11ck29 = 0 time = 300
.meas tran vdout1_11ck29 FIND v(dout1_11) AT=300.05n

* CHECK dout1_12 Vdout1_12ck29 = 1.8 time = 300
.meas tran vdout1_12ck29 FIND v(dout1_12) AT=300.05n

* CHECK dout1_13 Vdout1_13ck29 = 0 time = 300
.meas tran vdout1_13ck29 FIND v(dout1_13) AT=300.05n

* CHECK dout1_14 Vdout1_14ck29 = 0 time = 300
.meas tran vdout1_14ck29 FIND v(dout1_14) AT=300.05n

* CHECK dout1_15 Vdout1_15ck29 = 1.8 time = 300
.meas tran vdout1_15ck29 FIND v(dout1_15) AT=300.05n

* CHECK dout1_16 Vdout1_16ck29 = 1.8 time = 300
.meas tran vdout1_16ck29 FIND v(dout1_16) AT=300.05n

* CHECK dout1_17 Vdout1_17ck29 = 0 time = 300
.meas tran vdout1_17ck29 FIND v(dout1_17) AT=300.05n

* CHECK dout1_18 Vdout1_18ck29 = 0 time = 300
.meas tran vdout1_18ck29 FIND v(dout1_18) AT=300.05n

* CHECK dout1_19 Vdout1_19ck29 = 1.8 time = 300
.meas tran vdout1_19ck29 FIND v(dout1_19) AT=300.05n

* CHECK dout1_20 Vdout1_20ck29 = 0 time = 300
.meas tran vdout1_20ck29 FIND v(dout1_20) AT=300.05n

* CHECK dout1_21 Vdout1_21ck29 = 0 time = 300
.meas tran vdout1_21ck29 FIND v(dout1_21) AT=300.05n

* CHECK dout1_22 Vdout1_22ck29 = 0 time = 300
.meas tran vdout1_22ck29 FIND v(dout1_22) AT=300.05n

* CHECK dout1_23 Vdout1_23ck29 = 1.8 time = 300
.meas tran vdout1_23ck29 FIND v(dout1_23) AT=300.05n

* CHECK dout1_24 Vdout1_24ck29 = 1.8 time = 300
.meas tran vdout1_24ck29 FIND v(dout1_24) AT=300.05n

* CHECK dout1_25 Vdout1_25ck29 = 0 time = 300
.meas tran vdout1_25ck29 FIND v(dout1_25) AT=300.05n

* CHECK dout1_26 Vdout1_26ck29 = 0 time = 300
.meas tran vdout1_26ck29 FIND v(dout1_26) AT=300.05n

* CHECK dout1_27 Vdout1_27ck29 = 1.8 time = 300
.meas tran vdout1_27ck29 FIND v(dout1_27) AT=300.05n

* CHECK dout1_28 Vdout1_28ck29 = 1.8 time = 300
.meas tran vdout1_28ck29 FIND v(dout1_28) AT=300.05n

* CHECK dout1_29 Vdout1_29ck29 = 1.8 time = 300
.meas tran vdout1_29ck29 FIND v(dout1_29) AT=300.05n

* CHECK dout1_30 Vdout1_30ck29 = 1.8 time = 300
.meas tran vdout1_30ck29 FIND v(dout1_30) AT=300.05n

* CHECK dout1_31 Vdout1_31ck29 = 1.8 time = 300
.meas tran vdout1_31ck29 FIND v(dout1_31) AT=300.05n

* CHECK dout0_0 Vdout0_0ck30 = 0 time = 310
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=310.05n

* CHECK dout0_1 Vdout0_1ck30 = 0 time = 310
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=310.05n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 310
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=310.05n

* CHECK dout0_3 Vdout0_3ck30 = 1.8 time = 310
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=310.05n

* CHECK dout0_4 Vdout0_4ck30 = 1.8 time = 310
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=310.05n

* CHECK dout0_5 Vdout0_5ck30 = 1.8 time = 310
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=310.05n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 310
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=310.05n

* CHECK dout0_7 Vdout0_7ck30 = 1.8 time = 310
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=310.05n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 310
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=310.05n

* CHECK dout0_9 Vdout0_9ck30 = 1.8 time = 310
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=310.05n

* CHECK dout0_10 Vdout0_10ck30 = 1.8 time = 310
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=310.05n

* CHECK dout0_11 Vdout0_11ck30 = 0 time = 310
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=310.05n

* CHECK dout0_12 Vdout0_12ck30 = 1.8 time = 310
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=310.05n

* CHECK dout0_13 Vdout0_13ck30 = 0 time = 310
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=310.05n

* CHECK dout0_14 Vdout0_14ck30 = 0 time = 310
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=310.05n

* CHECK dout0_15 Vdout0_15ck30 = 1.8 time = 310
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=310.05n

* CHECK dout0_16 Vdout0_16ck30 = 1.8 time = 310
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=310.05n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 310
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=310.05n

* CHECK dout0_18 Vdout0_18ck30 = 0 time = 310
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=310.05n

* CHECK dout0_19 Vdout0_19ck30 = 1.8 time = 310
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=310.05n

* CHECK dout0_20 Vdout0_20ck30 = 0 time = 310
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=310.05n

* CHECK dout0_21 Vdout0_21ck30 = 0 time = 310
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=310.05n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 310
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=310.05n

* CHECK dout0_23 Vdout0_23ck30 = 1.8 time = 310
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=310.05n

* CHECK dout0_24 Vdout0_24ck30 = 1.8 time = 310
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=310.05n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 310
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=310.05n

* CHECK dout0_26 Vdout0_26ck30 = 0 time = 310
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=310.05n

* CHECK dout0_27 Vdout0_27ck30 = 1.8 time = 310
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=310.05n

* CHECK dout0_28 Vdout0_28ck30 = 1.8 time = 310
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=310.05n

* CHECK dout0_29 Vdout0_29ck30 = 1.8 time = 310
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=310.05n

* CHECK dout0_30 Vdout0_30ck30 = 1.8 time = 310
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=310.05n

* CHECK dout0_31 Vdout0_31ck30 = 1.8 time = 310
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=310.05n

* CHECK dout1_0 Vdout1_0ck31 = 1.8 time = 320
.meas tran vdout1_0ck31 FIND v(dout1_0) AT=320.05n

* CHECK dout1_1 Vdout1_1ck31 = 0 time = 320
.meas tran vdout1_1ck31 FIND v(dout1_1) AT=320.05n

* CHECK dout1_2 Vdout1_2ck31 = 0 time = 320
.meas tran vdout1_2ck31 FIND v(dout1_2) AT=320.05n

* CHECK dout1_3 Vdout1_3ck31 = 1.8 time = 320
.meas tran vdout1_3ck31 FIND v(dout1_3) AT=320.05n

* CHECK dout1_4 Vdout1_4ck31 = 1.8 time = 320
.meas tran vdout1_4ck31 FIND v(dout1_4) AT=320.05n

* CHECK dout1_5 Vdout1_5ck31 = 1.8 time = 320
.meas tran vdout1_5ck31 FIND v(dout1_5) AT=320.05n

* CHECK dout1_6 Vdout1_6ck31 = 1.8 time = 320
.meas tran vdout1_6ck31 FIND v(dout1_6) AT=320.05n

* CHECK dout1_7 Vdout1_7ck31 = 1.8 time = 320
.meas tran vdout1_7ck31 FIND v(dout1_7) AT=320.05n

* CHECK dout1_8 Vdout1_8ck31 = 1.8 time = 320
.meas tran vdout1_8ck31 FIND v(dout1_8) AT=320.05n

* CHECK dout1_9 Vdout1_9ck31 = 0 time = 320
.meas tran vdout1_9ck31 FIND v(dout1_9) AT=320.05n

* CHECK dout1_10 Vdout1_10ck31 = 1.8 time = 320
.meas tran vdout1_10ck31 FIND v(dout1_10) AT=320.05n

* CHECK dout1_11 Vdout1_11ck31 = 0 time = 320
.meas tran vdout1_11ck31 FIND v(dout1_11) AT=320.05n

* CHECK dout1_12 Vdout1_12ck31 = 1.8 time = 320
.meas tran vdout1_12ck31 FIND v(dout1_12) AT=320.05n

* CHECK dout1_13 Vdout1_13ck31 = 0 time = 320
.meas tran vdout1_13ck31 FIND v(dout1_13) AT=320.05n

* CHECK dout1_14 Vdout1_14ck31 = 1.8 time = 320
.meas tran vdout1_14ck31 FIND v(dout1_14) AT=320.05n

* CHECK dout1_15 Vdout1_15ck31 = 0 time = 320
.meas tran vdout1_15ck31 FIND v(dout1_15) AT=320.05n

* CHECK dout1_16 Vdout1_16ck31 = 1.8 time = 320
.meas tran vdout1_16ck31 FIND v(dout1_16) AT=320.05n

* CHECK dout1_17 Vdout1_17ck31 = 0 time = 320
.meas tran vdout1_17ck31 FIND v(dout1_17) AT=320.05n

* CHECK dout1_18 Vdout1_18ck31 = 1.8 time = 320
.meas tran vdout1_18ck31 FIND v(dout1_18) AT=320.05n

* CHECK dout1_19 Vdout1_19ck31 = 0 time = 320
.meas tran vdout1_19ck31 FIND v(dout1_19) AT=320.05n

* CHECK dout1_20 Vdout1_20ck31 = 0 time = 320
.meas tran vdout1_20ck31 FIND v(dout1_20) AT=320.05n

* CHECK dout1_21 Vdout1_21ck31 = 1.8 time = 320
.meas tran vdout1_21ck31 FIND v(dout1_21) AT=320.05n

* CHECK dout1_22 Vdout1_22ck31 = 0 time = 320
.meas tran vdout1_22ck31 FIND v(dout1_22) AT=320.05n

* CHECK dout1_23 Vdout1_23ck31 = 0 time = 320
.meas tran vdout1_23ck31 FIND v(dout1_23) AT=320.05n

* CHECK dout1_24 Vdout1_24ck31 = 1.8 time = 320
.meas tran vdout1_24ck31 FIND v(dout1_24) AT=320.05n

* CHECK dout1_25 Vdout1_25ck31 = 1.8 time = 320
.meas tran vdout1_25ck31 FIND v(dout1_25) AT=320.05n

* CHECK dout1_26 Vdout1_26ck31 = 1.8 time = 320
.meas tran vdout1_26ck31 FIND v(dout1_26) AT=320.05n

* CHECK dout1_27 Vdout1_27ck31 = 0 time = 320
.meas tran vdout1_27ck31 FIND v(dout1_27) AT=320.05n

* CHECK dout1_28 Vdout1_28ck31 = 0 time = 320
.meas tran vdout1_28ck31 FIND v(dout1_28) AT=320.05n

* CHECK dout1_29 Vdout1_29ck31 = 0 time = 320
.meas tran vdout1_29ck31 FIND v(dout1_29) AT=320.05n

* CHECK dout1_30 Vdout1_30ck31 = 1.8 time = 320
.meas tran vdout1_30ck31 FIND v(dout1_30) AT=320.05n

* CHECK dout1_31 Vdout1_31ck31 = 0 time = 320
.meas tran vdout1_31ck31 FIND v(dout1_31) AT=320.05n

* CHECK dout1_0 Vdout1_0ck33 = 0 time = 340
.meas tran vdout1_0ck33 FIND v(dout1_0) AT=340.05n

* CHECK dout1_1 Vdout1_1ck33 = 0 time = 340
.meas tran vdout1_1ck33 FIND v(dout1_1) AT=340.05n

* CHECK dout1_2 Vdout1_2ck33 = 0 time = 340
.meas tran vdout1_2ck33 FIND v(dout1_2) AT=340.05n

* CHECK dout1_3 Vdout1_3ck33 = 1.8 time = 340
.meas tran vdout1_3ck33 FIND v(dout1_3) AT=340.05n

* CHECK dout1_4 Vdout1_4ck33 = 1.8 time = 340
.meas tran vdout1_4ck33 FIND v(dout1_4) AT=340.05n

* CHECK dout1_5 Vdout1_5ck33 = 1.8 time = 340
.meas tran vdout1_5ck33 FIND v(dout1_5) AT=340.05n

* CHECK dout1_6 Vdout1_6ck33 = 0 time = 340
.meas tran vdout1_6ck33 FIND v(dout1_6) AT=340.05n

* CHECK dout1_7 Vdout1_7ck33 = 1.8 time = 340
.meas tran vdout1_7ck33 FIND v(dout1_7) AT=340.05n

* CHECK dout1_8 Vdout1_8ck33 = 0 time = 340
.meas tran vdout1_8ck33 FIND v(dout1_8) AT=340.05n

* CHECK dout1_9 Vdout1_9ck33 = 1.8 time = 340
.meas tran vdout1_9ck33 FIND v(dout1_9) AT=340.05n

* CHECK dout1_10 Vdout1_10ck33 = 1.8 time = 340
.meas tran vdout1_10ck33 FIND v(dout1_10) AT=340.05n

* CHECK dout1_11 Vdout1_11ck33 = 0 time = 340
.meas tran vdout1_11ck33 FIND v(dout1_11) AT=340.05n

* CHECK dout1_12 Vdout1_12ck33 = 1.8 time = 340
.meas tran vdout1_12ck33 FIND v(dout1_12) AT=340.05n

* CHECK dout1_13 Vdout1_13ck33 = 0 time = 340
.meas tran vdout1_13ck33 FIND v(dout1_13) AT=340.05n

* CHECK dout1_14 Vdout1_14ck33 = 0 time = 340
.meas tran vdout1_14ck33 FIND v(dout1_14) AT=340.05n

* CHECK dout1_15 Vdout1_15ck33 = 1.8 time = 340
.meas tran vdout1_15ck33 FIND v(dout1_15) AT=340.05n

* CHECK dout1_16 Vdout1_16ck33 = 1.8 time = 340
.meas tran vdout1_16ck33 FIND v(dout1_16) AT=340.05n

* CHECK dout1_17 Vdout1_17ck33 = 0 time = 340
.meas tran vdout1_17ck33 FIND v(dout1_17) AT=340.05n

* CHECK dout1_18 Vdout1_18ck33 = 0 time = 340
.meas tran vdout1_18ck33 FIND v(dout1_18) AT=340.05n

* CHECK dout1_19 Vdout1_19ck33 = 1.8 time = 340
.meas tran vdout1_19ck33 FIND v(dout1_19) AT=340.05n

* CHECK dout1_20 Vdout1_20ck33 = 0 time = 340
.meas tran vdout1_20ck33 FIND v(dout1_20) AT=340.05n

* CHECK dout1_21 Vdout1_21ck33 = 0 time = 340
.meas tran vdout1_21ck33 FIND v(dout1_21) AT=340.05n

* CHECK dout1_22 Vdout1_22ck33 = 0 time = 340
.meas tran vdout1_22ck33 FIND v(dout1_22) AT=340.05n

* CHECK dout1_23 Vdout1_23ck33 = 1.8 time = 340
.meas tran vdout1_23ck33 FIND v(dout1_23) AT=340.05n

* CHECK dout1_24 Vdout1_24ck33 = 1.8 time = 340
.meas tran vdout1_24ck33 FIND v(dout1_24) AT=340.05n

* CHECK dout1_25 Vdout1_25ck33 = 0 time = 340
.meas tran vdout1_25ck33 FIND v(dout1_25) AT=340.05n

* CHECK dout1_26 Vdout1_26ck33 = 0 time = 340
.meas tran vdout1_26ck33 FIND v(dout1_26) AT=340.05n

* CHECK dout1_27 Vdout1_27ck33 = 1.8 time = 340
.meas tran vdout1_27ck33 FIND v(dout1_27) AT=340.05n

* CHECK dout1_28 Vdout1_28ck33 = 1.8 time = 340
.meas tran vdout1_28ck33 FIND v(dout1_28) AT=340.05n

* CHECK dout1_29 Vdout1_29ck33 = 1.8 time = 340
.meas tran vdout1_29ck33 FIND v(dout1_29) AT=340.05n

* CHECK dout1_30 Vdout1_30ck33 = 1.8 time = 340
.meas tran vdout1_30ck33 FIND v(dout1_30) AT=340.05n

* CHECK dout1_31 Vdout1_31ck33 = 1.8 time = 340
.meas tran vdout1_31ck33 FIND v(dout1_31) AT=340.05n

* CHECK dout0_0 Vdout0_0ck34 = 0 time = 350
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=350.05n

* CHECK dout0_1 Vdout0_1ck34 = 0 time = 350
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=350.05n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 350
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=350.05n

* CHECK dout0_3 Vdout0_3ck34 = 1.8 time = 350
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=350.05n

* CHECK dout0_4 Vdout0_4ck34 = 1.8 time = 350
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=350.05n

* CHECK dout0_5 Vdout0_5ck34 = 1.8 time = 350
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=350.05n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 350
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=350.05n

* CHECK dout0_7 Vdout0_7ck34 = 1.8 time = 350
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=350.05n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 350
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=350.05n

* CHECK dout0_9 Vdout0_9ck34 = 1.8 time = 350
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=350.05n

* CHECK dout0_10 Vdout0_10ck34 = 1.8 time = 350
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=350.05n

* CHECK dout0_11 Vdout0_11ck34 = 0 time = 350
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=350.05n

* CHECK dout0_12 Vdout0_12ck34 = 1.8 time = 350
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=350.05n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 350
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=350.05n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 350
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=350.05n

* CHECK dout0_15 Vdout0_15ck34 = 1.8 time = 350
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=350.05n

* CHECK dout0_16 Vdout0_16ck34 = 1.8 time = 350
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=350.05n

* CHECK dout0_17 Vdout0_17ck34 = 0 time = 350
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=350.05n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 350
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=350.05n

* CHECK dout0_19 Vdout0_19ck34 = 1.8 time = 350
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=350.05n

* CHECK dout0_20 Vdout0_20ck34 = 0 time = 350
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=350.05n

* CHECK dout0_21 Vdout0_21ck34 = 0 time = 350
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=350.05n

* CHECK dout0_22 Vdout0_22ck34 = 0 time = 350
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=350.05n

* CHECK dout0_23 Vdout0_23ck34 = 1.8 time = 350
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=350.05n

* CHECK dout0_24 Vdout0_24ck34 = 1.8 time = 350
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=350.05n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 350
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=350.05n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 350
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=350.05n

* CHECK dout0_27 Vdout0_27ck34 = 1.8 time = 350
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=350.05n

* CHECK dout0_28 Vdout0_28ck34 = 1.8 time = 350
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=350.05n

* CHECK dout0_29 Vdout0_29ck34 = 1.8 time = 350
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=350.05n

* CHECK dout0_30 Vdout0_30ck34 = 1.8 time = 350
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=350.05n

* CHECK dout0_31 Vdout0_31ck34 = 1.8 time = 350
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=350.05n

* CHECK dout1_0 Vdout1_0ck34 = 1.8 time = 350
.meas tran vdout1_0ck34 FIND v(dout1_0) AT=350.05n

* CHECK dout1_1 Vdout1_1ck34 = 0 time = 350
.meas tran vdout1_1ck34 FIND v(dout1_1) AT=350.05n

* CHECK dout1_2 Vdout1_2ck34 = 0 time = 350
.meas tran vdout1_2ck34 FIND v(dout1_2) AT=350.05n

* CHECK dout1_3 Vdout1_3ck34 = 1.8 time = 350
.meas tran vdout1_3ck34 FIND v(dout1_3) AT=350.05n

* CHECK dout1_4 Vdout1_4ck34 = 1.8 time = 350
.meas tran vdout1_4ck34 FIND v(dout1_4) AT=350.05n

* CHECK dout1_5 Vdout1_5ck34 = 1.8 time = 350
.meas tran vdout1_5ck34 FIND v(dout1_5) AT=350.05n

* CHECK dout1_6 Vdout1_6ck34 = 1.8 time = 350
.meas tran vdout1_6ck34 FIND v(dout1_6) AT=350.05n

* CHECK dout1_7 Vdout1_7ck34 = 0 time = 350
.meas tran vdout1_7ck34 FIND v(dout1_7) AT=350.05n

* CHECK dout1_8 Vdout1_8ck34 = 1.8 time = 350
.meas tran vdout1_8ck34 FIND v(dout1_8) AT=350.05n

* CHECK dout1_9 Vdout1_9ck34 = 1.8 time = 350
.meas tran vdout1_9ck34 FIND v(dout1_9) AT=350.05n

* CHECK dout1_10 Vdout1_10ck34 = 1.8 time = 350
.meas tran vdout1_10ck34 FIND v(dout1_10) AT=350.05n

* CHECK dout1_11 Vdout1_11ck34 = 0 time = 350
.meas tran vdout1_11ck34 FIND v(dout1_11) AT=350.05n

* CHECK dout1_12 Vdout1_12ck34 = 1.8 time = 350
.meas tran vdout1_12ck34 FIND v(dout1_12) AT=350.05n

* CHECK dout1_13 Vdout1_13ck34 = 0 time = 350
.meas tran vdout1_13ck34 FIND v(dout1_13) AT=350.05n

* CHECK dout1_14 Vdout1_14ck34 = 1.8 time = 350
.meas tran vdout1_14ck34 FIND v(dout1_14) AT=350.05n

* CHECK dout1_15 Vdout1_15ck34 = 1.8 time = 350
.meas tran vdout1_15ck34 FIND v(dout1_15) AT=350.05n

* CHECK dout1_16 Vdout1_16ck34 = 0 time = 350
.meas tran vdout1_16ck34 FIND v(dout1_16) AT=350.05n

* CHECK dout1_17 Vdout1_17ck34 = 1.8 time = 350
.meas tran vdout1_17ck34 FIND v(dout1_17) AT=350.05n

* CHECK dout1_18 Vdout1_18ck34 = 0 time = 350
.meas tran vdout1_18ck34 FIND v(dout1_18) AT=350.05n

* CHECK dout1_19 Vdout1_19ck34 = 1.8 time = 350
.meas tran vdout1_19ck34 FIND v(dout1_19) AT=350.05n

* CHECK dout1_20 Vdout1_20ck34 = 0 time = 350
.meas tran vdout1_20ck34 FIND v(dout1_20) AT=350.05n

* CHECK dout1_21 Vdout1_21ck34 = 1.8 time = 350
.meas tran vdout1_21ck34 FIND v(dout1_21) AT=350.05n

* CHECK dout1_22 Vdout1_22ck34 = 0 time = 350
.meas tran vdout1_22ck34 FIND v(dout1_22) AT=350.05n

* CHECK dout1_23 Vdout1_23ck34 = 1.8 time = 350
.meas tran vdout1_23ck34 FIND v(dout1_23) AT=350.05n

* CHECK dout1_24 Vdout1_24ck34 = 0 time = 350
.meas tran vdout1_24ck34 FIND v(dout1_24) AT=350.05n

* CHECK dout1_25 Vdout1_25ck34 = 1.8 time = 350
.meas tran vdout1_25ck34 FIND v(dout1_25) AT=350.05n

* CHECK dout1_26 Vdout1_26ck34 = 0 time = 350
.meas tran vdout1_26ck34 FIND v(dout1_26) AT=350.05n

* CHECK dout1_27 Vdout1_27ck34 = 0 time = 350
.meas tran vdout1_27ck34 FIND v(dout1_27) AT=350.05n

* CHECK dout1_28 Vdout1_28ck34 = 1.8 time = 350
.meas tran vdout1_28ck34 FIND v(dout1_28) AT=350.05n

* CHECK dout1_29 Vdout1_29ck34 = 0 time = 350
.meas tran vdout1_29ck34 FIND v(dout1_29) AT=350.05n

* CHECK dout1_30 Vdout1_30ck34 = 1.8 time = 350
.meas tran vdout1_30ck34 FIND v(dout1_30) AT=350.05n

* CHECK dout1_31 Vdout1_31ck34 = 1.8 time = 350
.meas tran vdout1_31ck34 FIND v(dout1_31) AT=350.05n

* CHECK dout1_0 Vdout1_0ck35 = 1.8 time = 360
.meas tran vdout1_0ck35 FIND v(dout1_0) AT=360.05n

* CHECK dout1_1 Vdout1_1ck35 = 0 time = 360
.meas tran vdout1_1ck35 FIND v(dout1_1) AT=360.05n

* CHECK dout1_2 Vdout1_2ck35 = 0 time = 360
.meas tran vdout1_2ck35 FIND v(dout1_2) AT=360.05n

* CHECK dout1_3 Vdout1_3ck35 = 1.8 time = 360
.meas tran vdout1_3ck35 FIND v(dout1_3) AT=360.05n

* CHECK dout1_4 Vdout1_4ck35 = 1.8 time = 360
.meas tran vdout1_4ck35 FIND v(dout1_4) AT=360.05n

* CHECK dout1_5 Vdout1_5ck35 = 1.8 time = 360
.meas tran vdout1_5ck35 FIND v(dout1_5) AT=360.05n

* CHECK dout1_6 Vdout1_6ck35 = 1.8 time = 360
.meas tran vdout1_6ck35 FIND v(dout1_6) AT=360.05n

* CHECK dout1_7 Vdout1_7ck35 = 0 time = 360
.meas tran vdout1_7ck35 FIND v(dout1_7) AT=360.05n

* CHECK dout1_8 Vdout1_8ck35 = 1.8 time = 360
.meas tran vdout1_8ck35 FIND v(dout1_8) AT=360.05n

* CHECK dout1_9 Vdout1_9ck35 = 1.8 time = 360
.meas tran vdout1_9ck35 FIND v(dout1_9) AT=360.05n

* CHECK dout1_10 Vdout1_10ck35 = 1.8 time = 360
.meas tran vdout1_10ck35 FIND v(dout1_10) AT=360.05n

* CHECK dout1_11 Vdout1_11ck35 = 0 time = 360
.meas tran vdout1_11ck35 FIND v(dout1_11) AT=360.05n

* CHECK dout1_12 Vdout1_12ck35 = 1.8 time = 360
.meas tran vdout1_12ck35 FIND v(dout1_12) AT=360.05n

* CHECK dout1_13 Vdout1_13ck35 = 0 time = 360
.meas tran vdout1_13ck35 FIND v(dout1_13) AT=360.05n

* CHECK dout1_14 Vdout1_14ck35 = 1.8 time = 360
.meas tran vdout1_14ck35 FIND v(dout1_14) AT=360.05n

* CHECK dout1_15 Vdout1_15ck35 = 1.8 time = 360
.meas tran vdout1_15ck35 FIND v(dout1_15) AT=360.05n

* CHECK dout1_16 Vdout1_16ck35 = 0 time = 360
.meas tran vdout1_16ck35 FIND v(dout1_16) AT=360.05n

* CHECK dout1_17 Vdout1_17ck35 = 1.8 time = 360
.meas tran vdout1_17ck35 FIND v(dout1_17) AT=360.05n

* CHECK dout1_18 Vdout1_18ck35 = 0 time = 360
.meas tran vdout1_18ck35 FIND v(dout1_18) AT=360.05n

* CHECK dout1_19 Vdout1_19ck35 = 1.8 time = 360
.meas tran vdout1_19ck35 FIND v(dout1_19) AT=360.05n

* CHECK dout1_20 Vdout1_20ck35 = 0 time = 360
.meas tran vdout1_20ck35 FIND v(dout1_20) AT=360.05n

* CHECK dout1_21 Vdout1_21ck35 = 1.8 time = 360
.meas tran vdout1_21ck35 FIND v(dout1_21) AT=360.05n

* CHECK dout1_22 Vdout1_22ck35 = 0 time = 360
.meas tran vdout1_22ck35 FIND v(dout1_22) AT=360.05n

* CHECK dout1_23 Vdout1_23ck35 = 1.8 time = 360
.meas tran vdout1_23ck35 FIND v(dout1_23) AT=360.05n

* CHECK dout1_24 Vdout1_24ck35 = 0 time = 360
.meas tran vdout1_24ck35 FIND v(dout1_24) AT=360.05n

* CHECK dout1_25 Vdout1_25ck35 = 1.8 time = 360
.meas tran vdout1_25ck35 FIND v(dout1_25) AT=360.05n

* CHECK dout1_26 Vdout1_26ck35 = 0 time = 360
.meas tran vdout1_26ck35 FIND v(dout1_26) AT=360.05n

* CHECK dout1_27 Vdout1_27ck35 = 0 time = 360
.meas tran vdout1_27ck35 FIND v(dout1_27) AT=360.05n

* CHECK dout1_28 Vdout1_28ck35 = 1.8 time = 360
.meas tran vdout1_28ck35 FIND v(dout1_28) AT=360.05n

* CHECK dout1_29 Vdout1_29ck35 = 0 time = 360
.meas tran vdout1_29ck35 FIND v(dout1_29) AT=360.05n

* CHECK dout1_30 Vdout1_30ck35 = 1.8 time = 360
.meas tran vdout1_30ck35 FIND v(dout1_30) AT=360.05n

* CHECK dout1_31 Vdout1_31ck35 = 1.8 time = 360
.meas tran vdout1_31ck35 FIND v(dout1_31) AT=360.05n

* CHECK dout0_0 Vdout0_0ck36 = 1.8 time = 370
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=370.05n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 370
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=370.05n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 370
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=370.05n

* CHECK dout0_3 Vdout0_3ck36 = 1.8 time = 370
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=370.05n

* CHECK dout0_4 Vdout0_4ck36 = 1.8 time = 370
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=370.05n

* CHECK dout0_5 Vdout0_5ck36 = 1.8 time = 370
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=370.05n

* CHECK dout0_6 Vdout0_6ck36 = 1.8 time = 370
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=370.05n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 370
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=370.05n

* CHECK dout0_8 Vdout0_8ck36 = 1.8 time = 370
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=370.05n

* CHECK dout0_9 Vdout0_9ck36 = 1.8 time = 370
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=370.05n

* CHECK dout0_10 Vdout0_10ck36 = 1.8 time = 370
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=370.05n

* CHECK dout0_11 Vdout0_11ck36 = 0 time = 370
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=370.05n

* CHECK dout0_12 Vdout0_12ck36 = 1.8 time = 370
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=370.05n

* CHECK dout0_13 Vdout0_13ck36 = 0 time = 370
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=370.05n

* CHECK dout0_14 Vdout0_14ck36 = 1.8 time = 370
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=370.05n

* CHECK dout0_15 Vdout0_15ck36 = 1.8 time = 370
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=370.05n

* CHECK dout0_16 Vdout0_16ck36 = 0 time = 370
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=370.05n

* CHECK dout0_17 Vdout0_17ck36 = 1.8 time = 370
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=370.05n

* CHECK dout0_18 Vdout0_18ck36 = 0 time = 370
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=370.05n

* CHECK dout0_19 Vdout0_19ck36 = 1.8 time = 370
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=370.05n

* CHECK dout0_20 Vdout0_20ck36 = 0 time = 370
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=370.05n

* CHECK dout0_21 Vdout0_21ck36 = 1.8 time = 370
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=370.05n

* CHECK dout0_22 Vdout0_22ck36 = 0 time = 370
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=370.05n

* CHECK dout0_23 Vdout0_23ck36 = 1.8 time = 370
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=370.05n

* CHECK dout0_24 Vdout0_24ck36 = 0 time = 370
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=370.05n

* CHECK dout0_25 Vdout0_25ck36 = 1.8 time = 370
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=370.05n

* CHECK dout0_26 Vdout0_26ck36 = 0 time = 370
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=370.05n

* CHECK dout0_27 Vdout0_27ck36 = 0 time = 370
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=370.05n

* CHECK dout0_28 Vdout0_28ck36 = 1.8 time = 370
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=370.05n

* CHECK dout0_29 Vdout0_29ck36 = 0 time = 370
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=370.05n

* CHECK dout0_30 Vdout0_30ck36 = 1.8 time = 370
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=370.05n

* CHECK dout0_31 Vdout0_31ck36 = 1.8 time = 370
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=370.05n

* CHECK dout1_0 Vdout1_0ck36 = 0 time = 370
.meas tran vdout1_0ck36 FIND v(dout1_0) AT=370.05n

* CHECK dout1_1 Vdout1_1ck36 = 1.8 time = 370
.meas tran vdout1_1ck36 FIND v(dout1_1) AT=370.05n

* CHECK dout1_2 Vdout1_2ck36 = 0 time = 370
.meas tran vdout1_2ck36 FIND v(dout1_2) AT=370.05n

* CHECK dout1_3 Vdout1_3ck36 = 1.8 time = 370
.meas tran vdout1_3ck36 FIND v(dout1_3) AT=370.05n

* CHECK dout1_4 Vdout1_4ck36 = 0 time = 370
.meas tran vdout1_4ck36 FIND v(dout1_4) AT=370.05n

* CHECK dout1_5 Vdout1_5ck36 = 1.8 time = 370
.meas tran vdout1_5ck36 FIND v(dout1_5) AT=370.05n

* CHECK dout1_6 Vdout1_6ck36 = 1.8 time = 370
.meas tran vdout1_6ck36 FIND v(dout1_6) AT=370.05n

* CHECK dout1_7 Vdout1_7ck36 = 0 time = 370
.meas tran vdout1_7ck36 FIND v(dout1_7) AT=370.05n

* CHECK dout1_8 Vdout1_8ck36 = 0 time = 370
.meas tran vdout1_8ck36 FIND v(dout1_8) AT=370.05n

* CHECK dout1_9 Vdout1_9ck36 = 1.8 time = 370
.meas tran vdout1_9ck36 FIND v(dout1_9) AT=370.05n

* CHECK dout1_10 Vdout1_10ck36 = 1.8 time = 370
.meas tran vdout1_10ck36 FIND v(dout1_10) AT=370.05n

* CHECK dout1_11 Vdout1_11ck36 = 0 time = 370
.meas tran vdout1_11ck36 FIND v(dout1_11) AT=370.05n

* CHECK dout1_12 Vdout1_12ck36 = 0 time = 370
.meas tran vdout1_12ck36 FIND v(dout1_12) AT=370.05n

* CHECK dout1_13 Vdout1_13ck36 = 1.8 time = 370
.meas tran vdout1_13ck36 FIND v(dout1_13) AT=370.05n

* CHECK dout1_14 Vdout1_14ck36 = 1.8 time = 370
.meas tran vdout1_14ck36 FIND v(dout1_14) AT=370.05n

* CHECK dout1_15 Vdout1_15ck36 = 0 time = 370
.meas tran vdout1_15ck36 FIND v(dout1_15) AT=370.05n

* CHECK dout1_16 Vdout1_16ck36 = 0 time = 370
.meas tran vdout1_16ck36 FIND v(dout1_16) AT=370.05n

* CHECK dout1_17 Vdout1_17ck36 = 0 time = 370
.meas tran vdout1_17ck36 FIND v(dout1_17) AT=370.05n

* CHECK dout1_18 Vdout1_18ck36 = 1.8 time = 370
.meas tran vdout1_18ck36 FIND v(dout1_18) AT=370.05n

* CHECK dout1_19 Vdout1_19ck36 = 0 time = 370
.meas tran vdout1_19ck36 FIND v(dout1_19) AT=370.05n

* CHECK dout1_20 Vdout1_20ck36 = 0 time = 370
.meas tran vdout1_20ck36 FIND v(dout1_20) AT=370.05n

* CHECK dout1_21 Vdout1_21ck36 = 1.8 time = 370
.meas tran vdout1_21ck36 FIND v(dout1_21) AT=370.05n

* CHECK dout1_22 Vdout1_22ck36 = 1.8 time = 370
.meas tran vdout1_22ck36 FIND v(dout1_22) AT=370.05n

* CHECK dout1_23 Vdout1_23ck36 = 0 time = 370
.meas tran vdout1_23ck36 FIND v(dout1_23) AT=370.05n

* CHECK dout1_24 Vdout1_24ck36 = 1.8 time = 370
.meas tran vdout1_24ck36 FIND v(dout1_24) AT=370.05n

* CHECK dout1_25 Vdout1_25ck36 = 0 time = 370
.meas tran vdout1_25ck36 FIND v(dout1_25) AT=370.05n

* CHECK dout1_26 Vdout1_26ck36 = 0 time = 370
.meas tran vdout1_26ck36 FIND v(dout1_26) AT=370.05n

* CHECK dout1_27 Vdout1_27ck36 = 1.8 time = 370
.meas tran vdout1_27ck36 FIND v(dout1_27) AT=370.05n

* CHECK dout1_28 Vdout1_28ck36 = 0 time = 370
.meas tran vdout1_28ck36 FIND v(dout1_28) AT=370.05n

* CHECK dout1_29 Vdout1_29ck36 = 1.8 time = 370
.meas tran vdout1_29ck36 FIND v(dout1_29) AT=370.05n

* CHECK dout1_30 Vdout1_30ck36 = 0 time = 370
.meas tran vdout1_30ck36 FIND v(dout1_30) AT=370.05n

* CHECK dout1_31 Vdout1_31ck36 = 1.8 time = 370
.meas tran vdout1_31ck36 FIND v(dout1_31) AT=370.05n

* CHECK dout0_0 Vdout0_0ck37 = 0 time = 380
.meas tran vdout0_0ck37 FIND v(dout0_0) AT=380.05n

* CHECK dout0_1 Vdout0_1ck37 = 1.8 time = 380
.meas tran vdout0_1ck37 FIND v(dout0_1) AT=380.05n

* CHECK dout0_2 Vdout0_2ck37 = 0 time = 380
.meas tran vdout0_2ck37 FIND v(dout0_2) AT=380.05n

* CHECK dout0_3 Vdout0_3ck37 = 1.8 time = 380
.meas tran vdout0_3ck37 FIND v(dout0_3) AT=380.05n

* CHECK dout0_4 Vdout0_4ck37 = 0 time = 380
.meas tran vdout0_4ck37 FIND v(dout0_4) AT=380.05n

* CHECK dout0_5 Vdout0_5ck37 = 1.8 time = 380
.meas tran vdout0_5ck37 FIND v(dout0_5) AT=380.05n

* CHECK dout0_6 Vdout0_6ck37 = 1.8 time = 380
.meas tran vdout0_6ck37 FIND v(dout0_6) AT=380.05n

* CHECK dout0_7 Vdout0_7ck37 = 0 time = 380
.meas tran vdout0_7ck37 FIND v(dout0_7) AT=380.05n

* CHECK dout0_8 Vdout0_8ck37 = 0 time = 380
.meas tran vdout0_8ck37 FIND v(dout0_8) AT=380.05n

* CHECK dout0_9 Vdout0_9ck37 = 1.8 time = 380
.meas tran vdout0_9ck37 FIND v(dout0_9) AT=380.05n

* CHECK dout0_10 Vdout0_10ck37 = 1.8 time = 380
.meas tran vdout0_10ck37 FIND v(dout0_10) AT=380.05n

* CHECK dout0_11 Vdout0_11ck37 = 0 time = 380
.meas tran vdout0_11ck37 FIND v(dout0_11) AT=380.05n

* CHECK dout0_12 Vdout0_12ck37 = 0 time = 380
.meas tran vdout0_12ck37 FIND v(dout0_12) AT=380.05n

* CHECK dout0_13 Vdout0_13ck37 = 1.8 time = 380
.meas tran vdout0_13ck37 FIND v(dout0_13) AT=380.05n

* CHECK dout0_14 Vdout0_14ck37 = 1.8 time = 380
.meas tran vdout0_14ck37 FIND v(dout0_14) AT=380.05n

* CHECK dout0_15 Vdout0_15ck37 = 0 time = 380
.meas tran vdout0_15ck37 FIND v(dout0_15) AT=380.05n

* CHECK dout0_16 Vdout0_16ck37 = 0 time = 380
.meas tran vdout0_16ck37 FIND v(dout0_16) AT=380.05n

* CHECK dout0_17 Vdout0_17ck37 = 0 time = 380
.meas tran vdout0_17ck37 FIND v(dout0_17) AT=380.05n

* CHECK dout0_18 Vdout0_18ck37 = 1.8 time = 380
.meas tran vdout0_18ck37 FIND v(dout0_18) AT=380.05n

* CHECK dout0_19 Vdout0_19ck37 = 0 time = 380
.meas tran vdout0_19ck37 FIND v(dout0_19) AT=380.05n

* CHECK dout0_20 Vdout0_20ck37 = 0 time = 380
.meas tran vdout0_20ck37 FIND v(dout0_20) AT=380.05n

* CHECK dout0_21 Vdout0_21ck37 = 1.8 time = 380
.meas tran vdout0_21ck37 FIND v(dout0_21) AT=380.05n

* CHECK dout0_22 Vdout0_22ck37 = 1.8 time = 380
.meas tran vdout0_22ck37 FIND v(dout0_22) AT=380.05n

* CHECK dout0_23 Vdout0_23ck37 = 0 time = 380
.meas tran vdout0_23ck37 FIND v(dout0_23) AT=380.05n

* CHECK dout0_24 Vdout0_24ck37 = 1.8 time = 380
.meas tran vdout0_24ck37 FIND v(dout0_24) AT=380.05n

* CHECK dout0_25 Vdout0_25ck37 = 0 time = 380
.meas tran vdout0_25ck37 FIND v(dout0_25) AT=380.05n

* CHECK dout0_26 Vdout0_26ck37 = 0 time = 380
.meas tran vdout0_26ck37 FIND v(dout0_26) AT=380.05n

* CHECK dout0_27 Vdout0_27ck37 = 1.8 time = 380
.meas tran vdout0_27ck37 FIND v(dout0_27) AT=380.05n

* CHECK dout0_28 Vdout0_28ck37 = 0 time = 380
.meas tran vdout0_28ck37 FIND v(dout0_28) AT=380.05n

* CHECK dout0_29 Vdout0_29ck37 = 1.8 time = 380
.meas tran vdout0_29ck37 FIND v(dout0_29) AT=380.05n

* CHECK dout0_30 Vdout0_30ck37 = 0 time = 380
.meas tran vdout0_30ck37 FIND v(dout0_30) AT=380.05n

* CHECK dout0_31 Vdout0_31ck37 = 1.8 time = 380
.meas tran vdout0_31ck37 FIND v(dout0_31) AT=380.05n

* CHECK dout1_0 Vdout1_0ck37 = 0 time = 380
.meas tran vdout1_0ck37 FIND v(dout1_0) AT=380.05n

* CHECK dout1_1 Vdout1_1ck37 = 1.8 time = 380
.meas tran vdout1_1ck37 FIND v(dout1_1) AT=380.05n

* CHECK dout1_2 Vdout1_2ck37 = 0 time = 380
.meas tran vdout1_2ck37 FIND v(dout1_2) AT=380.05n

* CHECK dout1_3 Vdout1_3ck37 = 1.8 time = 380
.meas tran vdout1_3ck37 FIND v(dout1_3) AT=380.05n

* CHECK dout1_4 Vdout1_4ck37 = 0 time = 380
.meas tran vdout1_4ck37 FIND v(dout1_4) AT=380.05n

* CHECK dout1_5 Vdout1_5ck37 = 1.8 time = 380
.meas tran vdout1_5ck37 FIND v(dout1_5) AT=380.05n

* CHECK dout1_6 Vdout1_6ck37 = 1.8 time = 380
.meas tran vdout1_6ck37 FIND v(dout1_6) AT=380.05n

* CHECK dout1_7 Vdout1_7ck37 = 0 time = 380
.meas tran vdout1_7ck37 FIND v(dout1_7) AT=380.05n

* CHECK dout1_8 Vdout1_8ck37 = 0 time = 380
.meas tran vdout1_8ck37 FIND v(dout1_8) AT=380.05n

* CHECK dout1_9 Vdout1_9ck37 = 1.8 time = 380
.meas tran vdout1_9ck37 FIND v(dout1_9) AT=380.05n

* CHECK dout1_10 Vdout1_10ck37 = 1.8 time = 380
.meas tran vdout1_10ck37 FIND v(dout1_10) AT=380.05n

* CHECK dout1_11 Vdout1_11ck37 = 0 time = 380
.meas tran vdout1_11ck37 FIND v(dout1_11) AT=380.05n

* CHECK dout1_12 Vdout1_12ck37 = 0 time = 380
.meas tran vdout1_12ck37 FIND v(dout1_12) AT=380.05n

* CHECK dout1_13 Vdout1_13ck37 = 1.8 time = 380
.meas tran vdout1_13ck37 FIND v(dout1_13) AT=380.05n

* CHECK dout1_14 Vdout1_14ck37 = 1.8 time = 380
.meas tran vdout1_14ck37 FIND v(dout1_14) AT=380.05n

* CHECK dout1_15 Vdout1_15ck37 = 0 time = 380
.meas tran vdout1_15ck37 FIND v(dout1_15) AT=380.05n

* CHECK dout1_16 Vdout1_16ck37 = 0 time = 380
.meas tran vdout1_16ck37 FIND v(dout1_16) AT=380.05n

* CHECK dout1_17 Vdout1_17ck37 = 0 time = 380
.meas tran vdout1_17ck37 FIND v(dout1_17) AT=380.05n

* CHECK dout1_18 Vdout1_18ck37 = 1.8 time = 380
.meas tran vdout1_18ck37 FIND v(dout1_18) AT=380.05n

* CHECK dout1_19 Vdout1_19ck37 = 0 time = 380
.meas tran vdout1_19ck37 FIND v(dout1_19) AT=380.05n

* CHECK dout1_20 Vdout1_20ck37 = 0 time = 380
.meas tran vdout1_20ck37 FIND v(dout1_20) AT=380.05n

* CHECK dout1_21 Vdout1_21ck37 = 1.8 time = 380
.meas tran vdout1_21ck37 FIND v(dout1_21) AT=380.05n

* CHECK dout1_22 Vdout1_22ck37 = 1.8 time = 380
.meas tran vdout1_22ck37 FIND v(dout1_22) AT=380.05n

* CHECK dout1_23 Vdout1_23ck37 = 0 time = 380
.meas tran vdout1_23ck37 FIND v(dout1_23) AT=380.05n

* CHECK dout1_24 Vdout1_24ck37 = 1.8 time = 380
.meas tran vdout1_24ck37 FIND v(dout1_24) AT=380.05n

* CHECK dout1_25 Vdout1_25ck37 = 0 time = 380
.meas tran vdout1_25ck37 FIND v(dout1_25) AT=380.05n

* CHECK dout1_26 Vdout1_26ck37 = 0 time = 380
.meas tran vdout1_26ck37 FIND v(dout1_26) AT=380.05n

* CHECK dout1_27 Vdout1_27ck37 = 1.8 time = 380
.meas tran vdout1_27ck37 FIND v(dout1_27) AT=380.05n

* CHECK dout1_28 Vdout1_28ck37 = 0 time = 380
.meas tran vdout1_28ck37 FIND v(dout1_28) AT=380.05n

* CHECK dout1_29 Vdout1_29ck37 = 1.8 time = 380
.meas tran vdout1_29ck37 FIND v(dout1_29) AT=380.05n

* CHECK dout1_30 Vdout1_30ck37 = 0 time = 380
.meas tran vdout1_30ck37 FIND v(dout1_30) AT=380.05n

* CHECK dout1_31 Vdout1_31ck37 = 1.8 time = 380
.meas tran vdout1_31ck37 FIND v(dout1_31) AT=380.05n

* CHECK dout0_0 Vdout0_0ck39 = 1.8 time = 400
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=400.05n

* CHECK dout0_1 Vdout0_1ck39 = 1.8 time = 400
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=400.05n

* CHECK dout0_2 Vdout0_2ck39 = 1.8 time = 400
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=400.05n

* CHECK dout0_3 Vdout0_3ck39 = 1.8 time = 400
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=400.05n

* CHECK dout0_4 Vdout0_4ck39 = 1.8 time = 400
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=400.05n

* CHECK dout0_5 Vdout0_5ck39 = 1.8 time = 400
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=400.05n

* CHECK dout0_6 Vdout0_6ck39 = 1.8 time = 400
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=400.05n

* CHECK dout0_7 Vdout0_7ck39 = 1.8 time = 400
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=400.05n

* CHECK dout0_8 Vdout0_8ck39 = 1.8 time = 400
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=400.05n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 400
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=400.05n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 400
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=400.05n

* CHECK dout0_11 Vdout0_11ck39 = 1.8 time = 400
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=400.05n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 400
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=400.05n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 400
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=400.05n

* CHECK dout0_14 Vdout0_14ck39 = 0 time = 400
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=400.05n

* CHECK dout0_15 Vdout0_15ck39 = 0 time = 400
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=400.05n

* CHECK dout0_16 Vdout0_16ck39 = 0 time = 400
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=400.05n

* CHECK dout0_17 Vdout0_17ck39 = 0 time = 400
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=400.05n

* CHECK dout0_18 Vdout0_18ck39 = 0 time = 400
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=400.05n

* CHECK dout0_19 Vdout0_19ck39 = 0 time = 400
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=400.05n

* CHECK dout0_20 Vdout0_20ck39 = 1.8 time = 400
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=400.05n

* CHECK dout0_21 Vdout0_21ck39 = 1.8 time = 400
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=400.05n

* CHECK dout0_22 Vdout0_22ck39 = 1.8 time = 400
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=400.05n

* CHECK dout0_23 Vdout0_23ck39 = 1.8 time = 400
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=400.05n

* CHECK dout0_24 Vdout0_24ck39 = 1.8 time = 400
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=400.05n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 400
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=400.05n

* CHECK dout0_26 Vdout0_26ck39 = 0 time = 400
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=400.05n

* CHECK dout0_27 Vdout0_27ck39 = 0 time = 400
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=400.05n

* CHECK dout0_28 Vdout0_28ck39 = 0 time = 400
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=400.05n

* CHECK dout0_29 Vdout0_29ck39 = 1.8 time = 400
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=400.05n

* CHECK dout0_30 Vdout0_30ck39 = 1.8 time = 400
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=400.05n

* CHECK dout0_31 Vdout0_31ck39 = 1.8 time = 400
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=400.05n

* CHECK dout1_0 Vdout1_0ck41 = 1.8 time = 420
.meas tran vdout1_0ck41 FIND v(dout1_0) AT=420.05n

* CHECK dout1_1 Vdout1_1ck41 = 1.8 time = 420
.meas tran vdout1_1ck41 FIND v(dout1_1) AT=420.05n

* CHECK dout1_2 Vdout1_2ck41 = 1.8 time = 420
.meas tran vdout1_2ck41 FIND v(dout1_2) AT=420.05n

* CHECK dout1_3 Vdout1_3ck41 = 1.8 time = 420
.meas tran vdout1_3ck41 FIND v(dout1_3) AT=420.05n

* CHECK dout1_4 Vdout1_4ck41 = 1.8 time = 420
.meas tran vdout1_4ck41 FIND v(dout1_4) AT=420.05n

* CHECK dout1_5 Vdout1_5ck41 = 1.8 time = 420
.meas tran vdout1_5ck41 FIND v(dout1_5) AT=420.05n

* CHECK dout1_6 Vdout1_6ck41 = 1.8 time = 420
.meas tran vdout1_6ck41 FIND v(dout1_6) AT=420.05n

* CHECK dout1_7 Vdout1_7ck41 = 1.8 time = 420
.meas tran vdout1_7ck41 FIND v(dout1_7) AT=420.05n

* CHECK dout1_8 Vdout1_8ck41 = 1.8 time = 420
.meas tran vdout1_8ck41 FIND v(dout1_8) AT=420.05n

* CHECK dout1_9 Vdout1_9ck41 = 0 time = 420
.meas tran vdout1_9ck41 FIND v(dout1_9) AT=420.05n

* CHECK dout1_10 Vdout1_10ck41 = 0 time = 420
.meas tran vdout1_10ck41 FIND v(dout1_10) AT=420.05n

* CHECK dout1_11 Vdout1_11ck41 = 1.8 time = 420
.meas tran vdout1_11ck41 FIND v(dout1_11) AT=420.05n

* CHECK dout1_12 Vdout1_12ck41 = 0 time = 420
.meas tran vdout1_12ck41 FIND v(dout1_12) AT=420.05n

* CHECK dout1_13 Vdout1_13ck41 = 0 time = 420
.meas tran vdout1_13ck41 FIND v(dout1_13) AT=420.05n

* CHECK dout1_14 Vdout1_14ck41 = 0 time = 420
.meas tran vdout1_14ck41 FIND v(dout1_14) AT=420.05n

* CHECK dout1_15 Vdout1_15ck41 = 0 time = 420
.meas tran vdout1_15ck41 FIND v(dout1_15) AT=420.05n

* CHECK dout1_16 Vdout1_16ck41 = 0 time = 420
.meas tran vdout1_16ck41 FIND v(dout1_16) AT=420.05n

* CHECK dout1_17 Vdout1_17ck41 = 0 time = 420
.meas tran vdout1_17ck41 FIND v(dout1_17) AT=420.05n

* CHECK dout1_18 Vdout1_18ck41 = 0 time = 420
.meas tran vdout1_18ck41 FIND v(dout1_18) AT=420.05n

* CHECK dout1_19 Vdout1_19ck41 = 0 time = 420
.meas tran vdout1_19ck41 FIND v(dout1_19) AT=420.05n

* CHECK dout1_20 Vdout1_20ck41 = 1.8 time = 420
.meas tran vdout1_20ck41 FIND v(dout1_20) AT=420.05n

* CHECK dout1_21 Vdout1_21ck41 = 1.8 time = 420
.meas tran vdout1_21ck41 FIND v(dout1_21) AT=420.05n

* CHECK dout1_22 Vdout1_22ck41 = 1.8 time = 420
.meas tran vdout1_22ck41 FIND v(dout1_22) AT=420.05n

* CHECK dout1_23 Vdout1_23ck41 = 1.8 time = 420
.meas tran vdout1_23ck41 FIND v(dout1_23) AT=420.05n

* CHECK dout1_24 Vdout1_24ck41 = 1.8 time = 420
.meas tran vdout1_24ck41 FIND v(dout1_24) AT=420.05n

* CHECK dout1_25 Vdout1_25ck41 = 0 time = 420
.meas tran vdout1_25ck41 FIND v(dout1_25) AT=420.05n

* CHECK dout1_26 Vdout1_26ck41 = 0 time = 420
.meas tran vdout1_26ck41 FIND v(dout1_26) AT=420.05n

* CHECK dout1_27 Vdout1_27ck41 = 0 time = 420
.meas tran vdout1_27ck41 FIND v(dout1_27) AT=420.05n

* CHECK dout1_28 Vdout1_28ck41 = 0 time = 420
.meas tran vdout1_28ck41 FIND v(dout1_28) AT=420.05n

* CHECK dout1_29 Vdout1_29ck41 = 1.8 time = 420
.meas tran vdout1_29ck41 FIND v(dout1_29) AT=420.05n

* CHECK dout1_30 Vdout1_30ck41 = 1.8 time = 420
.meas tran vdout1_30ck41 FIND v(dout1_30) AT=420.05n

* CHECK dout1_31 Vdout1_31ck41 = 1.8 time = 420
.meas tran vdout1_31ck41 FIND v(dout1_31) AT=420.05n

* CHECK dout0_0 Vdout0_0ck42 = 1.8 time = 430
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=430.05n

* CHECK dout0_1 Vdout0_1ck42 = 0 time = 430
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=430.05n

* CHECK dout0_2 Vdout0_2ck42 = 0 time = 430
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=430.05n

* CHECK dout0_3 Vdout0_3ck42 = 1.8 time = 430
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=430.05n

* CHECK dout0_4 Vdout0_4ck42 = 1.8 time = 430
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=430.05n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 430
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=430.05n

* CHECK dout0_6 Vdout0_6ck42 = 1.8 time = 430
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=430.05n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 430
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=430.05n

* CHECK dout0_8 Vdout0_8ck42 = 1.8 time = 430
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=430.05n

* CHECK dout0_9 Vdout0_9ck42 = 1.8 time = 430
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=430.05n

* CHECK dout0_10 Vdout0_10ck42 = 1.8 time = 430
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=430.05n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 430
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=430.05n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 430
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=430.05n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 430
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=430.05n

* CHECK dout0_14 Vdout0_14ck42 = 1.8 time = 430
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=430.05n

* CHECK dout0_15 Vdout0_15ck42 = 1.8 time = 430
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=430.05n

* CHECK dout0_16 Vdout0_16ck42 = 0 time = 430
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=430.05n

* CHECK dout0_17 Vdout0_17ck42 = 1.8 time = 430
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=430.05n

* CHECK dout0_18 Vdout0_18ck42 = 0 time = 430
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=430.05n

* CHECK dout0_19 Vdout0_19ck42 = 1.8 time = 430
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=430.05n

* CHECK dout0_20 Vdout0_20ck42 = 0 time = 430
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=430.05n

* CHECK dout0_21 Vdout0_21ck42 = 1.8 time = 430
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=430.05n

* CHECK dout0_22 Vdout0_22ck42 = 0 time = 430
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=430.05n

* CHECK dout0_23 Vdout0_23ck42 = 1.8 time = 430
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=430.05n

* CHECK dout0_24 Vdout0_24ck42 = 0 time = 430
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=430.05n

* CHECK dout0_25 Vdout0_25ck42 = 1.8 time = 430
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=430.05n

* CHECK dout0_26 Vdout0_26ck42 = 0 time = 430
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=430.05n

* CHECK dout0_27 Vdout0_27ck42 = 0 time = 430
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=430.05n

* CHECK dout0_28 Vdout0_28ck42 = 1.8 time = 430
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=430.05n

* CHECK dout0_29 Vdout0_29ck42 = 0 time = 430
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=430.05n

* CHECK dout0_30 Vdout0_30ck42 = 1.8 time = 430
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=430.05n

* CHECK dout0_31 Vdout0_31ck42 = 1.8 time = 430
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=430.05n

* CHECK dout0_0 Vdout0_0ck44 = 0 time = 450
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=450.05n

* CHECK dout0_1 Vdout0_1ck44 = 1.8 time = 450
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=450.05n

* CHECK dout0_2 Vdout0_2ck44 = 0 time = 450
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=450.05n

* CHECK dout0_3 Vdout0_3ck44 = 1.8 time = 450
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=450.05n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 450
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=450.05n

* CHECK dout0_5 Vdout0_5ck44 = 1.8 time = 450
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=450.05n

* CHECK dout0_6 Vdout0_6ck44 = 1.8 time = 450
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=450.05n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 450
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=450.05n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 450
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=450.05n

* CHECK dout0_9 Vdout0_9ck44 = 1.8 time = 450
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=450.05n

* CHECK dout0_10 Vdout0_10ck44 = 1.8 time = 450
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=450.05n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 450
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=450.05n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 450
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=450.05n

* CHECK dout0_13 Vdout0_13ck44 = 1.8 time = 450
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=450.05n

* CHECK dout0_14 Vdout0_14ck44 = 1.8 time = 450
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=450.05n

* CHECK dout0_15 Vdout0_15ck44 = 0 time = 450
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=450.05n

* CHECK dout0_16 Vdout0_16ck44 = 0 time = 450
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=450.05n

* CHECK dout0_17 Vdout0_17ck44 = 0 time = 450
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=450.05n

* CHECK dout0_18 Vdout0_18ck44 = 1.8 time = 450
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=450.05n

* CHECK dout0_19 Vdout0_19ck44 = 0 time = 450
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=450.05n

* CHECK dout0_20 Vdout0_20ck44 = 0 time = 450
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=450.05n

* CHECK dout0_21 Vdout0_21ck44 = 1.8 time = 450
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=450.05n

* CHECK dout0_22 Vdout0_22ck44 = 1.8 time = 450
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=450.05n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 450
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=450.05n

* CHECK dout0_24 Vdout0_24ck44 = 1.8 time = 450
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=450.05n

* CHECK dout0_25 Vdout0_25ck44 = 0 time = 450
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=450.05n

* CHECK dout0_26 Vdout0_26ck44 = 0 time = 450
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=450.05n

* CHECK dout0_27 Vdout0_27ck44 = 1.8 time = 450
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=450.05n

* CHECK dout0_28 Vdout0_28ck44 = 0 time = 450
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=450.05n

* CHECK dout0_29 Vdout0_29ck44 = 1.8 time = 450
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=450.05n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 450
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=450.05n

* CHECK dout0_31 Vdout0_31ck44 = 1.8 time = 450
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=450.05n

* CHECK dout0_0 Vdout0_0ck46 = 1.8 time = 470
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=470.05n

* CHECK dout0_1 Vdout0_1ck46 = 0 time = 470
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=470.05n

* CHECK dout0_2 Vdout0_2ck46 = 0 time = 470
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=470.05n

* CHECK dout0_3 Vdout0_3ck46 = 1.8 time = 470
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=470.05n

* CHECK dout0_4 Vdout0_4ck46 = 1.8 time = 470
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=470.05n

* CHECK dout0_5 Vdout0_5ck46 = 1.8 time = 470
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=470.05n

* CHECK dout0_6 Vdout0_6ck46 = 1.8 time = 470
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=470.05n

* CHECK dout0_7 Vdout0_7ck46 = 0 time = 470
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=470.05n

* CHECK dout0_8 Vdout0_8ck46 = 1.8 time = 470
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=470.05n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 470
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=470.05n

* CHECK dout0_10 Vdout0_10ck46 = 1.8 time = 470
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=470.05n

* CHECK dout0_11 Vdout0_11ck46 = 0 time = 470
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=470.05n

* CHECK dout0_12 Vdout0_12ck46 = 1.8 time = 470
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=470.05n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 470
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=470.05n

* CHECK dout0_14 Vdout0_14ck46 = 1.8 time = 470
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=470.05n

* CHECK dout0_15 Vdout0_15ck46 = 1.8 time = 470
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=470.05n

* CHECK dout0_16 Vdout0_16ck46 = 0 time = 470
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=470.05n

* CHECK dout0_17 Vdout0_17ck46 = 1.8 time = 470
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=470.05n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 470
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=470.05n

* CHECK dout0_19 Vdout0_19ck46 = 1.8 time = 470
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=470.05n

* CHECK dout0_20 Vdout0_20ck46 = 0 time = 470
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=470.05n

* CHECK dout0_21 Vdout0_21ck46 = 1.8 time = 470
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=470.05n

* CHECK dout0_22 Vdout0_22ck46 = 0 time = 470
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=470.05n

* CHECK dout0_23 Vdout0_23ck46 = 1.8 time = 470
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=470.05n

* CHECK dout0_24 Vdout0_24ck46 = 0 time = 470
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=470.05n

* CHECK dout0_25 Vdout0_25ck46 = 1.8 time = 470
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=470.05n

* CHECK dout0_26 Vdout0_26ck46 = 0 time = 470
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=470.05n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 470
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=470.05n

* CHECK dout0_28 Vdout0_28ck46 = 1.8 time = 470
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=470.05n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 470
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=470.05n

* CHECK dout0_30 Vdout0_30ck46 = 1.8 time = 470
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=470.05n

* CHECK dout0_31 Vdout0_31ck46 = 1.8 time = 470
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=470.05n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 0 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 0 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 1.8 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 1.8 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 480
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=480.05n

* CHECK dout0_9 Vdout0_9ck47 = 1.8 time = 480
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=480.05n

* CHECK dout0_10 Vdout0_10ck47 = 1.8 time = 480
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=480.05n

* CHECK dout0_11 Vdout0_11ck47 = 0 time = 480
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=480.05n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 480
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=480.05n

* CHECK dout0_13 Vdout0_13ck47 = 1.8 time = 480
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=480.05n

* CHECK dout0_14 Vdout0_14ck47 = 0 time = 480
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=480.05n

* CHECK dout0_15 Vdout0_15ck47 = 0 time = 480
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=480.05n

* CHECK dout0_16 Vdout0_16ck47 = 1.8 time = 480
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=480.05n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 480
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=480.05n

* CHECK dout0_18 Vdout0_18ck47 = 0 time = 480
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=480.05n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 480
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=480.05n

* CHECK dout0_20 Vdout0_20ck47 = 0 time = 480
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=480.05n

* CHECK dout0_21 Vdout0_21ck47 = 1.8 time = 480
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=480.05n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 480
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=480.05n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 480
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=480.05n

* CHECK dout0_24 Vdout0_24ck47 = 0 time = 480
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=480.05n

* CHECK dout0_25 Vdout0_25ck47 = 1.8 time = 480
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=480.05n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 480
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=480.05n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 480
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=480.05n

* CHECK dout0_28 Vdout0_28ck47 = 0 time = 480
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=480.05n

* CHECK dout0_29 Vdout0_29ck47 = 1.8 time = 480
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=480.05n

* CHECK dout0_30 Vdout0_30ck47 = 1.8 time = 480
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=480.05n

* CHECK dout0_31 Vdout0_31ck47 = 1.8 time = 480
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=480.05n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 490
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=490.05n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 490
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=490.05n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 490
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=490.05n

* CHECK dout0_3 Vdout0_3ck48 = 1.8 time = 490
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=490.05n

* CHECK dout0_4 Vdout0_4ck48 = 1.8 time = 490
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=490.05n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 490
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=490.05n

* CHECK dout0_6 Vdout0_6ck48 = 1.8 time = 490
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=490.05n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 490
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=490.05n

* CHECK dout0_8 Vdout0_8ck48 = 1.8 time = 490
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=490.05n

* CHECK dout0_9 Vdout0_9ck48 = 1.8 time = 490
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=490.05n

* CHECK dout0_10 Vdout0_10ck48 = 1.8 time = 490
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=490.05n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 490
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=490.05n

* CHECK dout0_12 Vdout0_12ck48 = 1.8 time = 490
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=490.05n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 490
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=490.05n

* CHECK dout0_14 Vdout0_14ck48 = 1.8 time = 490
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=490.05n

* CHECK dout0_15 Vdout0_15ck48 = 1.8 time = 490
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=490.05n

* CHECK dout0_16 Vdout0_16ck48 = 0 time = 490
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=490.05n

* CHECK dout0_17 Vdout0_17ck48 = 1.8 time = 490
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=490.05n

* CHECK dout0_18 Vdout0_18ck48 = 0 time = 490
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=490.05n

* CHECK dout0_19 Vdout0_19ck48 = 1.8 time = 490
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=490.05n

* CHECK dout0_20 Vdout0_20ck48 = 0 time = 490
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=490.05n

* CHECK dout0_21 Vdout0_21ck48 = 1.8 time = 490
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=490.05n

* CHECK dout0_22 Vdout0_22ck48 = 0 time = 490
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=490.05n

* CHECK dout0_23 Vdout0_23ck48 = 1.8 time = 490
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=490.05n

* CHECK dout0_24 Vdout0_24ck48 = 0 time = 490
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=490.05n

* CHECK dout0_25 Vdout0_25ck48 = 1.8 time = 490
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=490.05n

* CHECK dout0_26 Vdout0_26ck48 = 0 time = 490
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=490.05n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 490
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=490.05n

* CHECK dout0_28 Vdout0_28ck48 = 1.8 time = 490
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=490.05n

* CHECK dout0_29 Vdout0_29ck48 = 0 time = 490
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=490.05n

* CHECK dout0_30 Vdout0_30ck48 = 1.8 time = 490
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=490.05n

* CHECK dout0_31 Vdout0_31ck48 = 1.8 time = 490
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=490.05n

* CHECK dout0_0 Vdout0_0ck49 = 1.8 time = 500
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=500.05n

* CHECK dout0_1 Vdout0_1ck49 = 0 time = 500
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=500.05n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 500
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=500.05n

* CHECK dout0_3 Vdout0_3ck49 = 1.8 time = 500
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=500.05n

* CHECK dout0_4 Vdout0_4ck49 = 1.8 time = 500
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=500.05n

* CHECK dout0_5 Vdout0_5ck49 = 1.8 time = 500
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=500.05n

* CHECK dout0_6 Vdout0_6ck49 = 1.8 time = 500
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=500.05n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 500
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=500.05n

* CHECK dout0_8 Vdout0_8ck49 = 1.8 time = 500
.meas tran vdout0_8ck49 FIND v(dout0_8) AT=500.05n

* CHECK dout0_9 Vdout0_9ck49 = 1.8 time = 500
.meas tran vdout0_9ck49 FIND v(dout0_9) AT=500.05n

* CHECK dout0_10 Vdout0_10ck49 = 1.8 time = 500
.meas tran vdout0_10ck49 FIND v(dout0_10) AT=500.05n

* CHECK dout0_11 Vdout0_11ck49 = 0 time = 500
.meas tran vdout0_11ck49 FIND v(dout0_11) AT=500.05n

* CHECK dout0_12 Vdout0_12ck49 = 1.8 time = 500
.meas tran vdout0_12ck49 FIND v(dout0_12) AT=500.05n

* CHECK dout0_13 Vdout0_13ck49 = 0 time = 500
.meas tran vdout0_13ck49 FIND v(dout0_13) AT=500.05n

* CHECK dout0_14 Vdout0_14ck49 = 1.8 time = 500
.meas tran vdout0_14ck49 FIND v(dout0_14) AT=500.05n

* CHECK dout0_15 Vdout0_15ck49 = 1.8 time = 500
.meas tran vdout0_15ck49 FIND v(dout0_15) AT=500.05n

* CHECK dout0_16 Vdout0_16ck49 = 0 time = 500
.meas tran vdout0_16ck49 FIND v(dout0_16) AT=500.05n

* CHECK dout0_17 Vdout0_17ck49 = 1.8 time = 500
.meas tran vdout0_17ck49 FIND v(dout0_17) AT=500.05n

* CHECK dout0_18 Vdout0_18ck49 = 0 time = 500
.meas tran vdout0_18ck49 FIND v(dout0_18) AT=500.05n

* CHECK dout0_19 Vdout0_19ck49 = 1.8 time = 500
.meas tran vdout0_19ck49 FIND v(dout0_19) AT=500.05n

* CHECK dout0_20 Vdout0_20ck49 = 0 time = 500
.meas tran vdout0_20ck49 FIND v(dout0_20) AT=500.05n

* CHECK dout0_21 Vdout0_21ck49 = 1.8 time = 500
.meas tran vdout0_21ck49 FIND v(dout0_21) AT=500.05n

* CHECK dout0_22 Vdout0_22ck49 = 0 time = 500
.meas tran vdout0_22ck49 FIND v(dout0_22) AT=500.05n

* CHECK dout0_23 Vdout0_23ck49 = 1.8 time = 500
.meas tran vdout0_23ck49 FIND v(dout0_23) AT=500.05n

* CHECK dout0_24 Vdout0_24ck49 = 0 time = 500
.meas tran vdout0_24ck49 FIND v(dout0_24) AT=500.05n

* CHECK dout0_25 Vdout0_25ck49 = 1.8 time = 500
.meas tran vdout0_25ck49 FIND v(dout0_25) AT=500.05n

* CHECK dout0_26 Vdout0_26ck49 = 0 time = 500
.meas tran vdout0_26ck49 FIND v(dout0_26) AT=500.05n

* CHECK dout0_27 Vdout0_27ck49 = 0 time = 500
.meas tran vdout0_27ck49 FIND v(dout0_27) AT=500.05n

* CHECK dout0_28 Vdout0_28ck49 = 1.8 time = 500
.meas tran vdout0_28ck49 FIND v(dout0_28) AT=500.05n

* CHECK dout0_29 Vdout0_29ck49 = 0 time = 500
.meas tran vdout0_29ck49 FIND v(dout0_29) AT=500.05n

* CHECK dout0_30 Vdout0_30ck49 = 1.8 time = 500
.meas tran vdout0_30ck49 FIND v(dout0_30) AT=500.05n

* CHECK dout0_31 Vdout0_31ck49 = 1.8 time = 500
.meas tran vdout0_31ck49 FIND v(dout0_31) AT=500.05n

* CHECK dout1_0 Vdout1_0ck49 = 1.8 time = 500
.meas tran vdout1_0ck49 FIND v(dout1_0) AT=500.05n

* CHECK dout1_1 Vdout1_1ck49 = 1.8 time = 500
.meas tran vdout1_1ck49 FIND v(dout1_1) AT=500.05n

* CHECK dout1_2 Vdout1_2ck49 = 1.8 time = 500
.meas tran vdout1_2ck49 FIND v(dout1_2) AT=500.05n

* CHECK dout1_3 Vdout1_3ck49 = 1.8 time = 500
.meas tran vdout1_3ck49 FIND v(dout1_3) AT=500.05n

* CHECK dout1_4 Vdout1_4ck49 = 1.8 time = 500
.meas tran vdout1_4ck49 FIND v(dout1_4) AT=500.05n

* CHECK dout1_5 Vdout1_5ck49 = 1.8 time = 500
.meas tran vdout1_5ck49 FIND v(dout1_5) AT=500.05n

* CHECK dout1_6 Vdout1_6ck49 = 1.8 time = 500
.meas tran vdout1_6ck49 FIND v(dout1_6) AT=500.05n

* CHECK dout1_7 Vdout1_7ck49 = 1.8 time = 500
.meas tran vdout1_7ck49 FIND v(dout1_7) AT=500.05n

* CHECK dout1_8 Vdout1_8ck49 = 1.8 time = 500
.meas tran vdout1_8ck49 FIND v(dout1_8) AT=500.05n

* CHECK dout1_9 Vdout1_9ck49 = 0 time = 500
.meas tran vdout1_9ck49 FIND v(dout1_9) AT=500.05n

* CHECK dout1_10 Vdout1_10ck49 = 0 time = 500
.meas tran vdout1_10ck49 FIND v(dout1_10) AT=500.05n

* CHECK dout1_11 Vdout1_11ck49 = 1.8 time = 500
.meas tran vdout1_11ck49 FIND v(dout1_11) AT=500.05n

* CHECK dout1_12 Vdout1_12ck49 = 0 time = 500
.meas tran vdout1_12ck49 FIND v(dout1_12) AT=500.05n

* CHECK dout1_13 Vdout1_13ck49 = 0 time = 500
.meas tran vdout1_13ck49 FIND v(dout1_13) AT=500.05n

* CHECK dout1_14 Vdout1_14ck49 = 0 time = 500
.meas tran vdout1_14ck49 FIND v(dout1_14) AT=500.05n

* CHECK dout1_15 Vdout1_15ck49 = 0 time = 500
.meas tran vdout1_15ck49 FIND v(dout1_15) AT=500.05n

* CHECK dout1_16 Vdout1_16ck49 = 0 time = 500
.meas tran vdout1_16ck49 FIND v(dout1_16) AT=500.05n

* CHECK dout1_17 Vdout1_17ck49 = 0 time = 500
.meas tran vdout1_17ck49 FIND v(dout1_17) AT=500.05n

* CHECK dout1_18 Vdout1_18ck49 = 0 time = 500
.meas tran vdout1_18ck49 FIND v(dout1_18) AT=500.05n

* CHECK dout1_19 Vdout1_19ck49 = 0 time = 500
.meas tran vdout1_19ck49 FIND v(dout1_19) AT=500.05n

* CHECK dout1_20 Vdout1_20ck49 = 1.8 time = 500
.meas tran vdout1_20ck49 FIND v(dout1_20) AT=500.05n

* CHECK dout1_21 Vdout1_21ck49 = 1.8 time = 500
.meas tran vdout1_21ck49 FIND v(dout1_21) AT=500.05n

* CHECK dout1_22 Vdout1_22ck49 = 1.8 time = 500
.meas tran vdout1_22ck49 FIND v(dout1_22) AT=500.05n

* CHECK dout1_23 Vdout1_23ck49 = 1.8 time = 500
.meas tran vdout1_23ck49 FIND v(dout1_23) AT=500.05n

* CHECK dout1_24 Vdout1_24ck49 = 1.8 time = 500
.meas tran vdout1_24ck49 FIND v(dout1_24) AT=500.05n

* CHECK dout1_25 Vdout1_25ck49 = 0 time = 500
.meas tran vdout1_25ck49 FIND v(dout1_25) AT=500.05n

* CHECK dout1_26 Vdout1_26ck49 = 0 time = 500
.meas tran vdout1_26ck49 FIND v(dout1_26) AT=500.05n

* CHECK dout1_27 Vdout1_27ck49 = 0 time = 500
.meas tran vdout1_27ck49 FIND v(dout1_27) AT=500.05n

* CHECK dout1_28 Vdout1_28ck49 = 0 time = 500
.meas tran vdout1_28ck49 FIND v(dout1_28) AT=500.05n

* CHECK dout1_29 Vdout1_29ck49 = 1.8 time = 500
.meas tran vdout1_29ck49 FIND v(dout1_29) AT=500.05n

* CHECK dout1_30 Vdout1_30ck49 = 1.8 time = 500
.meas tran vdout1_30ck49 FIND v(dout1_30) AT=500.05n

* CHECK dout1_31 Vdout1_31ck49 = 1.8 time = 500
.meas tran vdout1_31ck49 FIND v(dout1_31) AT=500.05n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 510
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=510.05n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 510
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=510.05n

* CHECK dout0_2 Vdout0_2ck50 = 0 time = 510
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=510.05n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 510
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=510.05n

* CHECK dout0_4 Vdout0_4ck50 = 1.8 time = 510
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=510.05n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 510
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=510.05n

* CHECK dout0_6 Vdout0_6ck50 = 1.8 time = 510
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=510.05n

* CHECK dout0_7 Vdout0_7ck50 = 1.8 time = 510
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=510.05n

* CHECK dout0_8 Vdout0_8ck50 = 0 time = 510
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=510.05n

* CHECK dout0_9 Vdout0_9ck50 = 1.8 time = 510
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=510.05n

* CHECK dout0_10 Vdout0_10ck50 = 1.8 time = 510
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=510.05n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 510
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=510.05n

* CHECK dout0_12 Vdout0_12ck50 = 1.8 time = 510
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=510.05n

* CHECK dout0_13 Vdout0_13ck50 = 1.8 time = 510
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=510.05n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 510
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=510.05n

* CHECK dout0_15 Vdout0_15ck50 = 0 time = 510
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=510.05n

* CHECK dout0_16 Vdout0_16ck50 = 1.8 time = 510
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=510.05n

* CHECK dout0_17 Vdout0_17ck50 = 1.8 time = 510
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=510.05n

* CHECK dout0_18 Vdout0_18ck50 = 0 time = 510
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=510.05n

* CHECK dout0_19 Vdout0_19ck50 = 0 time = 510
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=510.05n

* CHECK dout0_20 Vdout0_20ck50 = 0 time = 510
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=510.05n

* CHECK dout0_21 Vdout0_21ck50 = 1.8 time = 510
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=510.05n

* CHECK dout0_22 Vdout0_22ck50 = 1.8 time = 510
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=510.05n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 510
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=510.05n

* CHECK dout0_24 Vdout0_24ck50 = 0 time = 510
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=510.05n

* CHECK dout0_25 Vdout0_25ck50 = 1.8 time = 510
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=510.05n

* CHECK dout0_26 Vdout0_26ck50 = 0 time = 510
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=510.05n

* CHECK dout0_27 Vdout0_27ck50 = 0 time = 510
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=510.05n

* CHECK dout0_28 Vdout0_28ck50 = 0 time = 510
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=510.05n

* CHECK dout0_29 Vdout0_29ck50 = 1.8 time = 510
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=510.05n

* CHECK dout0_30 Vdout0_30ck50 = 1.8 time = 510
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=510.05n

* CHECK dout0_31 Vdout0_31ck50 = 1.8 time = 510
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=510.05n

* CHECK dout1_0 Vdout1_0ck50 = 0 time = 510
.meas tran vdout1_0ck50 FIND v(dout1_0) AT=510.05n

* CHECK dout1_1 Vdout1_1ck50 = 1.8 time = 510
.meas tran vdout1_1ck50 FIND v(dout1_1) AT=510.05n

* CHECK dout1_2 Vdout1_2ck50 = 0 time = 510
.meas tran vdout1_2ck50 FIND v(dout1_2) AT=510.05n

* CHECK dout1_3 Vdout1_3ck50 = 1.8 time = 510
.meas tran vdout1_3ck50 FIND v(dout1_3) AT=510.05n

* CHECK dout1_4 Vdout1_4ck50 = 0 time = 510
.meas tran vdout1_4ck50 FIND v(dout1_4) AT=510.05n

* CHECK dout1_5 Vdout1_5ck50 = 1.8 time = 510
.meas tran vdout1_5ck50 FIND v(dout1_5) AT=510.05n

* CHECK dout1_6 Vdout1_6ck50 = 1.8 time = 510
.meas tran vdout1_6ck50 FIND v(dout1_6) AT=510.05n

* CHECK dout1_7 Vdout1_7ck50 = 0 time = 510
.meas tran vdout1_7ck50 FIND v(dout1_7) AT=510.05n

* CHECK dout1_8 Vdout1_8ck50 = 0 time = 510
.meas tran vdout1_8ck50 FIND v(dout1_8) AT=510.05n

* CHECK dout1_9 Vdout1_9ck50 = 1.8 time = 510
.meas tran vdout1_9ck50 FIND v(dout1_9) AT=510.05n

* CHECK dout1_10 Vdout1_10ck50 = 1.8 time = 510
.meas tran vdout1_10ck50 FIND v(dout1_10) AT=510.05n

* CHECK dout1_11 Vdout1_11ck50 = 0 time = 510
.meas tran vdout1_11ck50 FIND v(dout1_11) AT=510.05n

* CHECK dout1_12 Vdout1_12ck50 = 0 time = 510
.meas tran vdout1_12ck50 FIND v(dout1_12) AT=510.05n

* CHECK dout1_13 Vdout1_13ck50 = 1.8 time = 510
.meas tran vdout1_13ck50 FIND v(dout1_13) AT=510.05n

* CHECK dout1_14 Vdout1_14ck50 = 1.8 time = 510
.meas tran vdout1_14ck50 FIND v(dout1_14) AT=510.05n

* CHECK dout1_15 Vdout1_15ck50 = 0 time = 510
.meas tran vdout1_15ck50 FIND v(dout1_15) AT=510.05n

* CHECK dout1_16 Vdout1_16ck50 = 0 time = 510
.meas tran vdout1_16ck50 FIND v(dout1_16) AT=510.05n

* CHECK dout1_17 Vdout1_17ck50 = 0 time = 510
.meas tran vdout1_17ck50 FIND v(dout1_17) AT=510.05n

* CHECK dout1_18 Vdout1_18ck50 = 1.8 time = 510
.meas tran vdout1_18ck50 FIND v(dout1_18) AT=510.05n

* CHECK dout1_19 Vdout1_19ck50 = 0 time = 510
.meas tran vdout1_19ck50 FIND v(dout1_19) AT=510.05n

* CHECK dout1_20 Vdout1_20ck50 = 0 time = 510
.meas tran vdout1_20ck50 FIND v(dout1_20) AT=510.05n

* CHECK dout1_21 Vdout1_21ck50 = 1.8 time = 510
.meas tran vdout1_21ck50 FIND v(dout1_21) AT=510.05n

* CHECK dout1_22 Vdout1_22ck50 = 1.8 time = 510
.meas tran vdout1_22ck50 FIND v(dout1_22) AT=510.05n

* CHECK dout1_23 Vdout1_23ck50 = 0 time = 510
.meas tran vdout1_23ck50 FIND v(dout1_23) AT=510.05n

* CHECK dout1_24 Vdout1_24ck50 = 1.8 time = 510
.meas tran vdout1_24ck50 FIND v(dout1_24) AT=510.05n

* CHECK dout1_25 Vdout1_25ck50 = 0 time = 510
.meas tran vdout1_25ck50 FIND v(dout1_25) AT=510.05n

* CHECK dout1_26 Vdout1_26ck50 = 0 time = 510
.meas tran vdout1_26ck50 FIND v(dout1_26) AT=510.05n

* CHECK dout1_27 Vdout1_27ck50 = 1.8 time = 510
.meas tran vdout1_27ck50 FIND v(dout1_27) AT=510.05n

* CHECK dout1_28 Vdout1_28ck50 = 0 time = 510
.meas tran vdout1_28ck50 FIND v(dout1_28) AT=510.05n

* CHECK dout1_29 Vdout1_29ck50 = 1.8 time = 510
.meas tran vdout1_29ck50 FIND v(dout1_29) AT=510.05n

* CHECK dout1_30 Vdout1_30ck50 = 0 time = 510
.meas tran vdout1_30ck50 FIND v(dout1_30) AT=510.05n

* CHECK dout1_31 Vdout1_31ck50 = 1.8 time = 510
.meas tran vdout1_31ck50 FIND v(dout1_31) AT=510.05n

* CHECK dout1_0 Vdout1_0ck51 = 0 time = 520
.meas tran vdout1_0ck51 FIND v(dout1_0) AT=520.05n

* CHECK dout1_1 Vdout1_1ck51 = 1.8 time = 520
.meas tran vdout1_1ck51 FIND v(dout1_1) AT=520.05n

* CHECK dout1_2 Vdout1_2ck51 = 0 time = 520
.meas tran vdout1_2ck51 FIND v(dout1_2) AT=520.05n

* CHECK dout1_3 Vdout1_3ck51 = 1.8 time = 520
.meas tran vdout1_3ck51 FIND v(dout1_3) AT=520.05n

* CHECK dout1_4 Vdout1_4ck51 = 0 time = 520
.meas tran vdout1_4ck51 FIND v(dout1_4) AT=520.05n

* CHECK dout1_5 Vdout1_5ck51 = 1.8 time = 520
.meas tran vdout1_5ck51 FIND v(dout1_5) AT=520.05n

* CHECK dout1_6 Vdout1_6ck51 = 1.8 time = 520
.meas tran vdout1_6ck51 FIND v(dout1_6) AT=520.05n

* CHECK dout1_7 Vdout1_7ck51 = 0 time = 520
.meas tran vdout1_7ck51 FIND v(dout1_7) AT=520.05n

* CHECK dout1_8 Vdout1_8ck51 = 0 time = 520
.meas tran vdout1_8ck51 FIND v(dout1_8) AT=520.05n

* CHECK dout1_9 Vdout1_9ck51 = 1.8 time = 520
.meas tran vdout1_9ck51 FIND v(dout1_9) AT=520.05n

* CHECK dout1_10 Vdout1_10ck51 = 1.8 time = 520
.meas tran vdout1_10ck51 FIND v(dout1_10) AT=520.05n

* CHECK dout1_11 Vdout1_11ck51 = 0 time = 520
.meas tran vdout1_11ck51 FIND v(dout1_11) AT=520.05n

* CHECK dout1_12 Vdout1_12ck51 = 0 time = 520
.meas tran vdout1_12ck51 FIND v(dout1_12) AT=520.05n

* CHECK dout1_13 Vdout1_13ck51 = 1.8 time = 520
.meas tran vdout1_13ck51 FIND v(dout1_13) AT=520.05n

* CHECK dout1_14 Vdout1_14ck51 = 1.8 time = 520
.meas tran vdout1_14ck51 FIND v(dout1_14) AT=520.05n

* CHECK dout1_15 Vdout1_15ck51 = 0 time = 520
.meas tran vdout1_15ck51 FIND v(dout1_15) AT=520.05n

* CHECK dout1_16 Vdout1_16ck51 = 0 time = 520
.meas tran vdout1_16ck51 FIND v(dout1_16) AT=520.05n

* CHECK dout1_17 Vdout1_17ck51 = 0 time = 520
.meas tran vdout1_17ck51 FIND v(dout1_17) AT=520.05n

* CHECK dout1_18 Vdout1_18ck51 = 1.8 time = 520
.meas tran vdout1_18ck51 FIND v(dout1_18) AT=520.05n

* CHECK dout1_19 Vdout1_19ck51 = 0 time = 520
.meas tran vdout1_19ck51 FIND v(dout1_19) AT=520.05n

* CHECK dout1_20 Vdout1_20ck51 = 0 time = 520
.meas tran vdout1_20ck51 FIND v(dout1_20) AT=520.05n

* CHECK dout1_21 Vdout1_21ck51 = 1.8 time = 520
.meas tran vdout1_21ck51 FIND v(dout1_21) AT=520.05n

* CHECK dout1_22 Vdout1_22ck51 = 1.8 time = 520
.meas tran vdout1_22ck51 FIND v(dout1_22) AT=520.05n

* CHECK dout1_23 Vdout1_23ck51 = 0 time = 520
.meas tran vdout1_23ck51 FIND v(dout1_23) AT=520.05n

* CHECK dout1_24 Vdout1_24ck51 = 1.8 time = 520
.meas tran vdout1_24ck51 FIND v(dout1_24) AT=520.05n

* CHECK dout1_25 Vdout1_25ck51 = 0 time = 520
.meas tran vdout1_25ck51 FIND v(dout1_25) AT=520.05n

* CHECK dout1_26 Vdout1_26ck51 = 0 time = 520
.meas tran vdout1_26ck51 FIND v(dout1_26) AT=520.05n

* CHECK dout1_27 Vdout1_27ck51 = 1.8 time = 520
.meas tran vdout1_27ck51 FIND v(dout1_27) AT=520.05n

* CHECK dout1_28 Vdout1_28ck51 = 0 time = 520
.meas tran vdout1_28ck51 FIND v(dout1_28) AT=520.05n

* CHECK dout1_29 Vdout1_29ck51 = 1.8 time = 520
.meas tran vdout1_29ck51 FIND v(dout1_29) AT=520.05n

* CHECK dout1_30 Vdout1_30ck51 = 0 time = 520
.meas tran vdout1_30ck51 FIND v(dout1_30) AT=520.05n

* CHECK dout1_31 Vdout1_31ck51 = 1.8 time = 520
.meas tran vdout1_31ck51 FIND v(dout1_31) AT=520.05n

* CHECK dout1_0 Vdout1_0ck54 = 1.8 time = 550
.meas tran vdout1_0ck54 FIND v(dout1_0) AT=550.05n

* CHECK dout1_1 Vdout1_1ck54 = 0 time = 550
.meas tran vdout1_1ck54 FIND v(dout1_1) AT=550.05n

* CHECK dout1_2 Vdout1_2ck54 = 0 time = 550
.meas tran vdout1_2ck54 FIND v(dout1_2) AT=550.05n

* CHECK dout1_3 Vdout1_3ck54 = 0 time = 550
.meas tran vdout1_3ck54 FIND v(dout1_3) AT=550.05n

* CHECK dout1_4 Vdout1_4ck54 = 0 time = 550
.meas tran vdout1_4ck54 FIND v(dout1_4) AT=550.05n

* CHECK dout1_5 Vdout1_5ck54 = 1.8 time = 550
.meas tran vdout1_5ck54 FIND v(dout1_5) AT=550.05n

* CHECK dout1_6 Vdout1_6ck54 = 0 time = 550
.meas tran vdout1_6ck54 FIND v(dout1_6) AT=550.05n

* CHECK dout1_7 Vdout1_7ck54 = 0 time = 550
.meas tran vdout1_7ck54 FIND v(dout1_7) AT=550.05n

* CHECK dout1_8 Vdout1_8ck54 = 1.8 time = 550
.meas tran vdout1_8ck54 FIND v(dout1_8) AT=550.05n

* CHECK dout1_9 Vdout1_9ck54 = 1.8 time = 550
.meas tran vdout1_9ck54 FIND v(dout1_9) AT=550.05n

* CHECK dout1_10 Vdout1_10ck54 = 0 time = 550
.meas tran vdout1_10ck54 FIND v(dout1_10) AT=550.05n

* CHECK dout1_11 Vdout1_11ck54 = 0 time = 550
.meas tran vdout1_11ck54 FIND v(dout1_11) AT=550.05n

* CHECK dout1_12 Vdout1_12ck54 = 0 time = 550
.meas tran vdout1_12ck54 FIND v(dout1_12) AT=550.05n

* CHECK dout1_13 Vdout1_13ck54 = 0 time = 550
.meas tran vdout1_13ck54 FIND v(dout1_13) AT=550.05n

* CHECK dout1_14 Vdout1_14ck54 = 1.8 time = 550
.meas tran vdout1_14ck54 FIND v(dout1_14) AT=550.05n

* CHECK dout1_15 Vdout1_15ck54 = 0 time = 550
.meas tran vdout1_15ck54 FIND v(dout1_15) AT=550.05n

* CHECK dout1_16 Vdout1_16ck54 = 1.8 time = 550
.meas tran vdout1_16ck54 FIND v(dout1_16) AT=550.05n

* CHECK dout1_17 Vdout1_17ck54 = 1.8 time = 550
.meas tran vdout1_17ck54 FIND v(dout1_17) AT=550.05n

* CHECK dout1_18 Vdout1_18ck54 = 1.8 time = 550
.meas tran vdout1_18ck54 FIND v(dout1_18) AT=550.05n

* CHECK dout1_19 Vdout1_19ck54 = 1.8 time = 550
.meas tran vdout1_19ck54 FIND v(dout1_19) AT=550.05n

* CHECK dout1_20 Vdout1_20ck54 = 0 time = 550
.meas tran vdout1_20ck54 FIND v(dout1_20) AT=550.05n

* CHECK dout1_21 Vdout1_21ck54 = 0 time = 550
.meas tran vdout1_21ck54 FIND v(dout1_21) AT=550.05n

* CHECK dout1_22 Vdout1_22ck54 = 1.8 time = 550
.meas tran vdout1_22ck54 FIND v(dout1_22) AT=550.05n

* CHECK dout1_23 Vdout1_23ck54 = 0 time = 550
.meas tran vdout1_23ck54 FIND v(dout1_23) AT=550.05n

* CHECK dout1_24 Vdout1_24ck54 = 0 time = 550
.meas tran vdout1_24ck54 FIND v(dout1_24) AT=550.05n

* CHECK dout1_25 Vdout1_25ck54 = 1.8 time = 550
.meas tran vdout1_25ck54 FIND v(dout1_25) AT=550.05n

* CHECK dout1_26 Vdout1_26ck54 = 1.8 time = 550
.meas tran vdout1_26ck54 FIND v(dout1_26) AT=550.05n

* CHECK dout1_27 Vdout1_27ck54 = 0 time = 550
.meas tran vdout1_27ck54 FIND v(dout1_27) AT=550.05n

* CHECK dout1_28 Vdout1_28ck54 = 1.8 time = 550
.meas tran vdout1_28ck54 FIND v(dout1_28) AT=550.05n

* CHECK dout1_29 Vdout1_29ck54 = 0 time = 550
.meas tran vdout1_29ck54 FIND v(dout1_29) AT=550.05n

* CHECK dout1_30 Vdout1_30ck54 = 1.8 time = 550
.meas tran vdout1_30ck54 FIND v(dout1_30) AT=550.05n

* CHECK dout1_31 Vdout1_31ck54 = 1.8 time = 550
.meas tran vdout1_31ck54 FIND v(dout1_31) AT=550.05n

* CHECK dout1_0 Vdout1_0ck55 = 0 time = 560
.meas tran vdout1_0ck55 FIND v(dout1_0) AT=560.05n

* CHECK dout1_1 Vdout1_1ck55 = 0 time = 560
.meas tran vdout1_1ck55 FIND v(dout1_1) AT=560.05n

* CHECK dout1_2 Vdout1_2ck55 = 1.8 time = 560
.meas tran vdout1_2ck55 FIND v(dout1_2) AT=560.05n

* CHECK dout1_3 Vdout1_3ck55 = 1.8 time = 560
.meas tran vdout1_3ck55 FIND v(dout1_3) AT=560.05n

* CHECK dout1_4 Vdout1_4ck55 = 0 time = 560
.meas tran vdout1_4ck55 FIND v(dout1_4) AT=560.05n

* CHECK dout1_5 Vdout1_5ck55 = 1.8 time = 560
.meas tran vdout1_5ck55 FIND v(dout1_5) AT=560.05n

* CHECK dout1_6 Vdout1_6ck55 = 0 time = 560
.meas tran vdout1_6ck55 FIND v(dout1_6) AT=560.05n

* CHECK dout1_7 Vdout1_7ck55 = 0 time = 560
.meas tran vdout1_7ck55 FIND v(dout1_7) AT=560.05n

* CHECK dout1_8 Vdout1_8ck55 = 0 time = 560
.meas tran vdout1_8ck55 FIND v(dout1_8) AT=560.05n

* CHECK dout1_9 Vdout1_9ck55 = 1.8 time = 560
.meas tran vdout1_9ck55 FIND v(dout1_9) AT=560.05n

* CHECK dout1_10 Vdout1_10ck55 = 0 time = 560
.meas tran vdout1_10ck55 FIND v(dout1_10) AT=560.05n

* CHECK dout1_11 Vdout1_11ck55 = 0 time = 560
.meas tran vdout1_11ck55 FIND v(dout1_11) AT=560.05n

* CHECK dout1_12 Vdout1_12ck55 = 0 time = 560
.meas tran vdout1_12ck55 FIND v(dout1_12) AT=560.05n

* CHECK dout1_13 Vdout1_13ck55 = 1.8 time = 560
.meas tran vdout1_13ck55 FIND v(dout1_13) AT=560.05n

* CHECK dout1_14 Vdout1_14ck55 = 0 time = 560
.meas tran vdout1_14ck55 FIND v(dout1_14) AT=560.05n

* CHECK dout1_15 Vdout1_15ck55 = 1.8 time = 560
.meas tran vdout1_15ck55 FIND v(dout1_15) AT=560.05n

* CHECK dout1_16 Vdout1_16ck55 = 1.8 time = 560
.meas tran vdout1_16ck55 FIND v(dout1_16) AT=560.05n

* CHECK dout1_17 Vdout1_17ck55 = 1.8 time = 560
.meas tran vdout1_17ck55 FIND v(dout1_17) AT=560.05n

* CHECK dout1_18 Vdout1_18ck55 = 1.8 time = 560
.meas tran vdout1_18ck55 FIND v(dout1_18) AT=560.05n

* CHECK dout1_19 Vdout1_19ck55 = 0 time = 560
.meas tran vdout1_19ck55 FIND v(dout1_19) AT=560.05n

* CHECK dout1_20 Vdout1_20ck55 = 0 time = 560
.meas tran vdout1_20ck55 FIND v(dout1_20) AT=560.05n

* CHECK dout1_21 Vdout1_21ck55 = 0 time = 560
.meas tran vdout1_21ck55 FIND v(dout1_21) AT=560.05n

* CHECK dout1_22 Vdout1_22ck55 = 1.8 time = 560
.meas tran vdout1_22ck55 FIND v(dout1_22) AT=560.05n

* CHECK dout1_23 Vdout1_23ck55 = 0 time = 560
.meas tran vdout1_23ck55 FIND v(dout1_23) AT=560.05n

* CHECK dout1_24 Vdout1_24ck55 = 0 time = 560
.meas tran vdout1_24ck55 FIND v(dout1_24) AT=560.05n

* CHECK dout1_25 Vdout1_25ck55 = 1.8 time = 560
.meas tran vdout1_25ck55 FIND v(dout1_25) AT=560.05n

* CHECK dout1_26 Vdout1_26ck55 = 0 time = 560
.meas tran vdout1_26ck55 FIND v(dout1_26) AT=560.05n

* CHECK dout1_27 Vdout1_27ck55 = 0 time = 560
.meas tran vdout1_27ck55 FIND v(dout1_27) AT=560.05n

* CHECK dout1_28 Vdout1_28ck55 = 0 time = 560
.meas tran vdout1_28ck55 FIND v(dout1_28) AT=560.05n

* CHECK dout1_29 Vdout1_29ck55 = 1.8 time = 560
.meas tran vdout1_29ck55 FIND v(dout1_29) AT=560.05n

* CHECK dout1_30 Vdout1_30ck55 = 1.8 time = 560
.meas tran vdout1_30ck55 FIND v(dout1_30) AT=560.05n

* CHECK dout1_31 Vdout1_31ck55 = 1.8 time = 560
.meas tran vdout1_31ck55 FIND v(dout1_31) AT=560.05n

* CHECK dout1_0 Vdout1_0ck57 = 0 time = 580
.meas tran vdout1_0ck57 FIND v(dout1_0) AT=580.05n

* CHECK dout1_1 Vdout1_1ck57 = 0 time = 580
.meas tran vdout1_1ck57 FIND v(dout1_1) AT=580.05n

* CHECK dout1_2 Vdout1_2ck57 = 1.8 time = 580
.meas tran vdout1_2ck57 FIND v(dout1_2) AT=580.05n

* CHECK dout1_3 Vdout1_3ck57 = 1.8 time = 580
.meas tran vdout1_3ck57 FIND v(dout1_3) AT=580.05n

* CHECK dout1_4 Vdout1_4ck57 = 0 time = 580
.meas tran vdout1_4ck57 FIND v(dout1_4) AT=580.05n

* CHECK dout1_5 Vdout1_5ck57 = 1.8 time = 580
.meas tran vdout1_5ck57 FIND v(dout1_5) AT=580.05n

* CHECK dout1_6 Vdout1_6ck57 = 0 time = 580
.meas tran vdout1_6ck57 FIND v(dout1_6) AT=580.05n

* CHECK dout1_7 Vdout1_7ck57 = 0 time = 580
.meas tran vdout1_7ck57 FIND v(dout1_7) AT=580.05n

* CHECK dout1_8 Vdout1_8ck57 = 0 time = 580
.meas tran vdout1_8ck57 FIND v(dout1_8) AT=580.05n

* CHECK dout1_9 Vdout1_9ck57 = 1.8 time = 580
.meas tran vdout1_9ck57 FIND v(dout1_9) AT=580.05n

* CHECK dout1_10 Vdout1_10ck57 = 0 time = 580
.meas tran vdout1_10ck57 FIND v(dout1_10) AT=580.05n

* CHECK dout1_11 Vdout1_11ck57 = 0 time = 580
.meas tran vdout1_11ck57 FIND v(dout1_11) AT=580.05n

* CHECK dout1_12 Vdout1_12ck57 = 0 time = 580
.meas tran vdout1_12ck57 FIND v(dout1_12) AT=580.05n

* CHECK dout1_13 Vdout1_13ck57 = 1.8 time = 580
.meas tran vdout1_13ck57 FIND v(dout1_13) AT=580.05n

* CHECK dout1_14 Vdout1_14ck57 = 0 time = 580
.meas tran vdout1_14ck57 FIND v(dout1_14) AT=580.05n

* CHECK dout1_15 Vdout1_15ck57 = 1.8 time = 580
.meas tran vdout1_15ck57 FIND v(dout1_15) AT=580.05n

* CHECK dout1_16 Vdout1_16ck57 = 1.8 time = 580
.meas tran vdout1_16ck57 FIND v(dout1_16) AT=580.05n

* CHECK dout1_17 Vdout1_17ck57 = 1.8 time = 580
.meas tran vdout1_17ck57 FIND v(dout1_17) AT=580.05n

* CHECK dout1_18 Vdout1_18ck57 = 1.8 time = 580
.meas tran vdout1_18ck57 FIND v(dout1_18) AT=580.05n

* CHECK dout1_19 Vdout1_19ck57 = 0 time = 580
.meas tran vdout1_19ck57 FIND v(dout1_19) AT=580.05n

* CHECK dout1_20 Vdout1_20ck57 = 0 time = 580
.meas tran vdout1_20ck57 FIND v(dout1_20) AT=580.05n

* CHECK dout1_21 Vdout1_21ck57 = 0 time = 580
.meas tran vdout1_21ck57 FIND v(dout1_21) AT=580.05n

* CHECK dout1_22 Vdout1_22ck57 = 1.8 time = 580
.meas tran vdout1_22ck57 FIND v(dout1_22) AT=580.05n

* CHECK dout1_23 Vdout1_23ck57 = 0 time = 580
.meas tran vdout1_23ck57 FIND v(dout1_23) AT=580.05n

* CHECK dout1_24 Vdout1_24ck57 = 0 time = 580
.meas tran vdout1_24ck57 FIND v(dout1_24) AT=580.05n

* CHECK dout1_25 Vdout1_25ck57 = 1.8 time = 580
.meas tran vdout1_25ck57 FIND v(dout1_25) AT=580.05n

* CHECK dout1_26 Vdout1_26ck57 = 0 time = 580
.meas tran vdout1_26ck57 FIND v(dout1_26) AT=580.05n

* CHECK dout1_27 Vdout1_27ck57 = 0 time = 580
.meas tran vdout1_27ck57 FIND v(dout1_27) AT=580.05n

* CHECK dout1_28 Vdout1_28ck57 = 0 time = 580
.meas tran vdout1_28ck57 FIND v(dout1_28) AT=580.05n

* CHECK dout1_29 Vdout1_29ck57 = 1.8 time = 580
.meas tran vdout1_29ck57 FIND v(dout1_29) AT=580.05n

* CHECK dout1_30 Vdout1_30ck57 = 1.8 time = 580
.meas tran vdout1_30ck57 FIND v(dout1_30) AT=580.05n

* CHECK dout1_31 Vdout1_31ck57 = 1.8 time = 580
.meas tran vdout1_31ck57 FIND v(dout1_31) AT=580.05n

* CHECK dout1_0 Vdout1_0ck58 = 0 time = 590
.meas tran vdout1_0ck58 FIND v(dout1_0) AT=590.05n

* CHECK dout1_1 Vdout1_1ck58 = 0 time = 590
.meas tran vdout1_1ck58 FIND v(dout1_1) AT=590.05n

* CHECK dout1_2 Vdout1_2ck58 = 1.8 time = 590
.meas tran vdout1_2ck58 FIND v(dout1_2) AT=590.05n

* CHECK dout1_3 Vdout1_3ck58 = 1.8 time = 590
.meas tran vdout1_3ck58 FIND v(dout1_3) AT=590.05n

* CHECK dout1_4 Vdout1_4ck58 = 0 time = 590
.meas tran vdout1_4ck58 FIND v(dout1_4) AT=590.05n

* CHECK dout1_5 Vdout1_5ck58 = 1.8 time = 590
.meas tran vdout1_5ck58 FIND v(dout1_5) AT=590.05n

* CHECK dout1_6 Vdout1_6ck58 = 0 time = 590
.meas tran vdout1_6ck58 FIND v(dout1_6) AT=590.05n

* CHECK dout1_7 Vdout1_7ck58 = 0 time = 590
.meas tran vdout1_7ck58 FIND v(dout1_7) AT=590.05n

* CHECK dout1_8 Vdout1_8ck58 = 0 time = 590
.meas tran vdout1_8ck58 FIND v(dout1_8) AT=590.05n

* CHECK dout1_9 Vdout1_9ck58 = 1.8 time = 590
.meas tran vdout1_9ck58 FIND v(dout1_9) AT=590.05n

* CHECK dout1_10 Vdout1_10ck58 = 0 time = 590
.meas tran vdout1_10ck58 FIND v(dout1_10) AT=590.05n

* CHECK dout1_11 Vdout1_11ck58 = 0 time = 590
.meas tran vdout1_11ck58 FIND v(dout1_11) AT=590.05n

* CHECK dout1_12 Vdout1_12ck58 = 0 time = 590
.meas tran vdout1_12ck58 FIND v(dout1_12) AT=590.05n

* CHECK dout1_13 Vdout1_13ck58 = 1.8 time = 590
.meas tran vdout1_13ck58 FIND v(dout1_13) AT=590.05n

* CHECK dout1_14 Vdout1_14ck58 = 0 time = 590
.meas tran vdout1_14ck58 FIND v(dout1_14) AT=590.05n

* CHECK dout1_15 Vdout1_15ck58 = 1.8 time = 590
.meas tran vdout1_15ck58 FIND v(dout1_15) AT=590.05n

* CHECK dout1_16 Vdout1_16ck58 = 1.8 time = 590
.meas tran vdout1_16ck58 FIND v(dout1_16) AT=590.05n

* CHECK dout1_17 Vdout1_17ck58 = 1.8 time = 590
.meas tran vdout1_17ck58 FIND v(dout1_17) AT=590.05n

* CHECK dout1_18 Vdout1_18ck58 = 1.8 time = 590
.meas tran vdout1_18ck58 FIND v(dout1_18) AT=590.05n

* CHECK dout1_19 Vdout1_19ck58 = 0 time = 590
.meas tran vdout1_19ck58 FIND v(dout1_19) AT=590.05n

* CHECK dout1_20 Vdout1_20ck58 = 0 time = 590
.meas tran vdout1_20ck58 FIND v(dout1_20) AT=590.05n

* CHECK dout1_21 Vdout1_21ck58 = 0 time = 590
.meas tran vdout1_21ck58 FIND v(dout1_21) AT=590.05n

* CHECK dout1_22 Vdout1_22ck58 = 1.8 time = 590
.meas tran vdout1_22ck58 FIND v(dout1_22) AT=590.05n

* CHECK dout1_23 Vdout1_23ck58 = 0 time = 590
.meas tran vdout1_23ck58 FIND v(dout1_23) AT=590.05n

* CHECK dout1_24 Vdout1_24ck58 = 0 time = 590
.meas tran vdout1_24ck58 FIND v(dout1_24) AT=590.05n

* CHECK dout1_25 Vdout1_25ck58 = 1.8 time = 590
.meas tran vdout1_25ck58 FIND v(dout1_25) AT=590.05n

* CHECK dout1_26 Vdout1_26ck58 = 0 time = 590
.meas tran vdout1_26ck58 FIND v(dout1_26) AT=590.05n

* CHECK dout1_27 Vdout1_27ck58 = 0 time = 590
.meas tran vdout1_27ck58 FIND v(dout1_27) AT=590.05n

* CHECK dout1_28 Vdout1_28ck58 = 0 time = 590
.meas tran vdout1_28ck58 FIND v(dout1_28) AT=590.05n

* CHECK dout1_29 Vdout1_29ck58 = 1.8 time = 590
.meas tran vdout1_29ck58 FIND v(dout1_29) AT=590.05n

* CHECK dout1_30 Vdout1_30ck58 = 1.8 time = 590
.meas tran vdout1_30ck58 FIND v(dout1_30) AT=590.05n

* CHECK dout1_31 Vdout1_31ck58 = 1.8 time = 590
.meas tran vdout1_31ck58 FIND v(dout1_31) AT=590.05n

* CHECK dout0_0 Vdout0_0ck59 = 0 time = 600
.meas tran vdout0_0ck59 FIND v(dout0_0) AT=600.05n

* CHECK dout0_1 Vdout0_1ck59 = 0 time = 600
.meas tran vdout0_1ck59 FIND v(dout0_1) AT=600.05n

* CHECK dout0_2 Vdout0_2ck59 = 1.8 time = 600
.meas tran vdout0_2ck59 FIND v(dout0_2) AT=600.05n

* CHECK dout0_3 Vdout0_3ck59 = 0 time = 600
.meas tran vdout0_3ck59 FIND v(dout0_3) AT=600.05n

* CHECK dout0_4 Vdout0_4ck59 = 0 time = 600
.meas tran vdout0_4ck59 FIND v(dout0_4) AT=600.05n

* CHECK dout0_5 Vdout0_5ck59 = 1.8 time = 600
.meas tran vdout0_5ck59 FIND v(dout0_5) AT=600.05n

* CHECK dout0_6 Vdout0_6ck59 = 0 time = 600
.meas tran vdout0_6ck59 FIND v(dout0_6) AT=600.05n

* CHECK dout0_7 Vdout0_7ck59 = 1.8 time = 600
.meas tran vdout0_7ck59 FIND v(dout0_7) AT=600.05n

* CHECK dout0_8 Vdout0_8ck59 = 0 time = 600
.meas tran vdout0_8ck59 FIND v(dout0_8) AT=600.05n

* CHECK dout0_9 Vdout0_9ck59 = 1.8 time = 600
.meas tran vdout0_9ck59 FIND v(dout0_9) AT=600.05n

* CHECK dout0_10 Vdout0_10ck59 = 0 time = 600
.meas tran vdout0_10ck59 FIND v(dout0_10) AT=600.05n

* CHECK dout0_11 Vdout0_11ck59 = 1.8 time = 600
.meas tran vdout0_11ck59 FIND v(dout0_11) AT=600.05n

* CHECK dout0_12 Vdout0_12ck59 = 1.8 time = 600
.meas tran vdout0_12ck59 FIND v(dout0_12) AT=600.05n

* CHECK dout0_13 Vdout0_13ck59 = 0 time = 600
.meas tran vdout0_13ck59 FIND v(dout0_13) AT=600.05n

* CHECK dout0_14 Vdout0_14ck59 = 0 time = 600
.meas tran vdout0_14ck59 FIND v(dout0_14) AT=600.05n

* CHECK dout0_15 Vdout0_15ck59 = 0 time = 600
.meas tran vdout0_15ck59 FIND v(dout0_15) AT=600.05n

* CHECK dout0_16 Vdout0_16ck59 = 1.8 time = 600
.meas tran vdout0_16ck59 FIND v(dout0_16) AT=600.05n

* CHECK dout0_17 Vdout0_17ck59 = 1.8 time = 600
.meas tran vdout0_17ck59 FIND v(dout0_17) AT=600.05n

* CHECK dout0_18 Vdout0_18ck59 = 1.8 time = 600
.meas tran vdout0_18ck59 FIND v(dout0_18) AT=600.05n

* CHECK dout0_19 Vdout0_19ck59 = 0 time = 600
.meas tran vdout0_19ck59 FIND v(dout0_19) AT=600.05n

* CHECK dout0_20 Vdout0_20ck59 = 1.8 time = 600
.meas tran vdout0_20ck59 FIND v(dout0_20) AT=600.05n

* CHECK dout0_21 Vdout0_21ck59 = 1.8 time = 600
.meas tran vdout0_21ck59 FIND v(dout0_21) AT=600.05n

* CHECK dout0_22 Vdout0_22ck59 = 1.8 time = 600
.meas tran vdout0_22ck59 FIND v(dout0_22) AT=600.05n

* CHECK dout0_23 Vdout0_23ck59 = 1.8 time = 600
.meas tran vdout0_23ck59 FIND v(dout0_23) AT=600.05n

* CHECK dout0_24 Vdout0_24ck59 = 0 time = 600
.meas tran vdout0_24ck59 FIND v(dout0_24) AT=600.05n

* CHECK dout0_25 Vdout0_25ck59 = 0 time = 600
.meas tran vdout0_25ck59 FIND v(dout0_25) AT=600.05n

* CHECK dout0_26 Vdout0_26ck59 = 0 time = 600
.meas tran vdout0_26ck59 FIND v(dout0_26) AT=600.05n

* CHECK dout0_27 Vdout0_27ck59 = 1.8 time = 600
.meas tran vdout0_27ck59 FIND v(dout0_27) AT=600.05n

* CHECK dout0_28 Vdout0_28ck59 = 1.8 time = 600
.meas tran vdout0_28ck59 FIND v(dout0_28) AT=600.05n

* CHECK dout0_29 Vdout0_29ck59 = 0 time = 600
.meas tran vdout0_29ck59 FIND v(dout0_29) AT=600.05n

* CHECK dout0_30 Vdout0_30ck59 = 0 time = 600
.meas tran vdout0_30ck59 FIND v(dout0_30) AT=600.05n

* CHECK dout0_31 Vdout0_31ck59 = 1.8 time = 600
.meas tran vdout0_31ck59 FIND v(dout0_31) AT=600.05n

* CHECK dout1_0 Vdout1_0ck59 = 0 time = 600
.meas tran vdout1_0ck59 FIND v(dout1_0) AT=600.05n

* CHECK dout1_1 Vdout1_1ck59 = 0 time = 600
.meas tran vdout1_1ck59 FIND v(dout1_1) AT=600.05n

* CHECK dout1_2 Vdout1_2ck59 = 1.8 time = 600
.meas tran vdout1_2ck59 FIND v(dout1_2) AT=600.05n

* CHECK dout1_3 Vdout1_3ck59 = 1.8 time = 600
.meas tran vdout1_3ck59 FIND v(dout1_3) AT=600.05n

* CHECK dout1_4 Vdout1_4ck59 = 0 time = 600
.meas tran vdout1_4ck59 FIND v(dout1_4) AT=600.05n

* CHECK dout1_5 Vdout1_5ck59 = 1.8 time = 600
.meas tran vdout1_5ck59 FIND v(dout1_5) AT=600.05n

* CHECK dout1_6 Vdout1_6ck59 = 0 time = 600
.meas tran vdout1_6ck59 FIND v(dout1_6) AT=600.05n

* CHECK dout1_7 Vdout1_7ck59 = 0 time = 600
.meas tran vdout1_7ck59 FIND v(dout1_7) AT=600.05n

* CHECK dout1_8 Vdout1_8ck59 = 0 time = 600
.meas tran vdout1_8ck59 FIND v(dout1_8) AT=600.05n

* CHECK dout1_9 Vdout1_9ck59 = 1.8 time = 600
.meas tran vdout1_9ck59 FIND v(dout1_9) AT=600.05n

* CHECK dout1_10 Vdout1_10ck59 = 0 time = 600
.meas tran vdout1_10ck59 FIND v(dout1_10) AT=600.05n

* CHECK dout1_11 Vdout1_11ck59 = 0 time = 600
.meas tran vdout1_11ck59 FIND v(dout1_11) AT=600.05n

* CHECK dout1_12 Vdout1_12ck59 = 0 time = 600
.meas tran vdout1_12ck59 FIND v(dout1_12) AT=600.05n

* CHECK dout1_13 Vdout1_13ck59 = 1.8 time = 600
.meas tran vdout1_13ck59 FIND v(dout1_13) AT=600.05n

* CHECK dout1_14 Vdout1_14ck59 = 0 time = 600
.meas tran vdout1_14ck59 FIND v(dout1_14) AT=600.05n

* CHECK dout1_15 Vdout1_15ck59 = 1.8 time = 600
.meas tran vdout1_15ck59 FIND v(dout1_15) AT=600.05n

* CHECK dout1_16 Vdout1_16ck59 = 1.8 time = 600
.meas tran vdout1_16ck59 FIND v(dout1_16) AT=600.05n

* CHECK dout1_17 Vdout1_17ck59 = 1.8 time = 600
.meas tran vdout1_17ck59 FIND v(dout1_17) AT=600.05n

* CHECK dout1_18 Vdout1_18ck59 = 1.8 time = 600
.meas tran vdout1_18ck59 FIND v(dout1_18) AT=600.05n

* CHECK dout1_19 Vdout1_19ck59 = 0 time = 600
.meas tran vdout1_19ck59 FIND v(dout1_19) AT=600.05n

* CHECK dout1_20 Vdout1_20ck59 = 0 time = 600
.meas tran vdout1_20ck59 FIND v(dout1_20) AT=600.05n

* CHECK dout1_21 Vdout1_21ck59 = 0 time = 600
.meas tran vdout1_21ck59 FIND v(dout1_21) AT=600.05n

* CHECK dout1_22 Vdout1_22ck59 = 1.8 time = 600
.meas tran vdout1_22ck59 FIND v(dout1_22) AT=600.05n

* CHECK dout1_23 Vdout1_23ck59 = 0 time = 600
.meas tran vdout1_23ck59 FIND v(dout1_23) AT=600.05n

* CHECK dout1_24 Vdout1_24ck59 = 0 time = 600
.meas tran vdout1_24ck59 FIND v(dout1_24) AT=600.05n

* CHECK dout1_25 Vdout1_25ck59 = 1.8 time = 600
.meas tran vdout1_25ck59 FIND v(dout1_25) AT=600.05n

* CHECK dout1_26 Vdout1_26ck59 = 0 time = 600
.meas tran vdout1_26ck59 FIND v(dout1_26) AT=600.05n

* CHECK dout1_27 Vdout1_27ck59 = 0 time = 600
.meas tran vdout1_27ck59 FIND v(dout1_27) AT=600.05n

* CHECK dout1_28 Vdout1_28ck59 = 0 time = 600
.meas tran vdout1_28ck59 FIND v(dout1_28) AT=600.05n

* CHECK dout1_29 Vdout1_29ck59 = 1.8 time = 600
.meas tran vdout1_29ck59 FIND v(dout1_29) AT=600.05n

* CHECK dout1_30 Vdout1_30ck59 = 1.8 time = 600
.meas tran vdout1_30ck59 FIND v(dout1_30) AT=600.05n

* CHECK dout1_31 Vdout1_31ck59 = 1.8 time = 600
.meas tran vdout1_31ck59 FIND v(dout1_31) AT=600.05n

* CHECK dout0_0 Vdout0_0ck60 = 0 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 1.8 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 1.8 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 0 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 1.8 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_8 Vdout0_8ck60 = 0 time = 610
.meas tran vdout0_8ck60 FIND v(dout0_8) AT=610.05n

* CHECK dout0_9 Vdout0_9ck60 = 1.8 time = 610
.meas tran vdout0_9ck60 FIND v(dout0_9) AT=610.05n

* CHECK dout0_10 Vdout0_10ck60 = 0 time = 610
.meas tran vdout0_10ck60 FIND v(dout0_10) AT=610.05n

* CHECK dout0_11 Vdout0_11ck60 = 1.8 time = 610
.meas tran vdout0_11ck60 FIND v(dout0_11) AT=610.05n

* CHECK dout0_12 Vdout0_12ck60 = 1.8 time = 610
.meas tran vdout0_12ck60 FIND v(dout0_12) AT=610.05n

* CHECK dout0_13 Vdout0_13ck60 = 0 time = 610
.meas tran vdout0_13ck60 FIND v(dout0_13) AT=610.05n

* CHECK dout0_14 Vdout0_14ck60 = 0 time = 610
.meas tran vdout0_14ck60 FIND v(dout0_14) AT=610.05n

* CHECK dout0_15 Vdout0_15ck60 = 0 time = 610
.meas tran vdout0_15ck60 FIND v(dout0_15) AT=610.05n

* CHECK dout0_16 Vdout0_16ck60 = 1.8 time = 610
.meas tran vdout0_16ck60 FIND v(dout0_16) AT=610.05n

* CHECK dout0_17 Vdout0_17ck60 = 1.8 time = 610
.meas tran vdout0_17ck60 FIND v(dout0_17) AT=610.05n

* CHECK dout0_18 Vdout0_18ck60 = 1.8 time = 610
.meas tran vdout0_18ck60 FIND v(dout0_18) AT=610.05n

* CHECK dout0_19 Vdout0_19ck60 = 0 time = 610
.meas tran vdout0_19ck60 FIND v(dout0_19) AT=610.05n

* CHECK dout0_20 Vdout0_20ck60 = 1.8 time = 610
.meas tran vdout0_20ck60 FIND v(dout0_20) AT=610.05n

* CHECK dout0_21 Vdout0_21ck60 = 1.8 time = 610
.meas tran vdout0_21ck60 FIND v(dout0_21) AT=610.05n

* CHECK dout0_22 Vdout0_22ck60 = 1.8 time = 610
.meas tran vdout0_22ck60 FIND v(dout0_22) AT=610.05n

* CHECK dout0_23 Vdout0_23ck60 = 1.8 time = 610
.meas tran vdout0_23ck60 FIND v(dout0_23) AT=610.05n

* CHECK dout0_24 Vdout0_24ck60 = 0 time = 610
.meas tran vdout0_24ck60 FIND v(dout0_24) AT=610.05n

* CHECK dout0_25 Vdout0_25ck60 = 0 time = 610
.meas tran vdout0_25ck60 FIND v(dout0_25) AT=610.05n

* CHECK dout0_26 Vdout0_26ck60 = 0 time = 610
.meas tran vdout0_26ck60 FIND v(dout0_26) AT=610.05n

* CHECK dout0_27 Vdout0_27ck60 = 1.8 time = 610
.meas tran vdout0_27ck60 FIND v(dout0_27) AT=610.05n

* CHECK dout0_28 Vdout0_28ck60 = 1.8 time = 610
.meas tran vdout0_28ck60 FIND v(dout0_28) AT=610.05n

* CHECK dout0_29 Vdout0_29ck60 = 0 time = 610
.meas tran vdout0_29ck60 FIND v(dout0_29) AT=610.05n

* CHECK dout0_30 Vdout0_30ck60 = 0 time = 610
.meas tran vdout0_30ck60 FIND v(dout0_30) AT=610.05n

* CHECK dout0_31 Vdout0_31ck60 = 1.8 time = 610
.meas tran vdout0_31ck60 FIND v(dout0_31) AT=610.05n

* CHECK dout0_0 Vdout0_0ck61 = 1.8 time = 620
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=620.05n

* CHECK dout0_1 Vdout0_1ck61 = 1.8 time = 620
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=620.05n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 620
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=620.05n

* CHECK dout0_3 Vdout0_3ck61 = 1.8 time = 620
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=620.05n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 620
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=620.05n

* CHECK dout0_5 Vdout0_5ck61 = 0 time = 620
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=620.05n

* CHECK dout0_6 Vdout0_6ck61 = 1.8 time = 620
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=620.05n

* CHECK dout0_7 Vdout0_7ck61 = 0 time = 620
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=620.05n

* CHECK dout0_8 Vdout0_8ck61 = 0 time = 620
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=620.05n

* CHECK dout0_9 Vdout0_9ck61 = 1.8 time = 620
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=620.05n

* CHECK dout0_10 Vdout0_10ck61 = 1.8 time = 620
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=620.05n

* CHECK dout0_11 Vdout0_11ck61 = 1.8 time = 620
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=620.05n

* CHECK dout0_12 Vdout0_12ck61 = 1.8 time = 620
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=620.05n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 620
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=620.05n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 620
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=620.05n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 620
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=620.05n

* CHECK dout0_16 Vdout0_16ck61 = 1.8 time = 620
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=620.05n

* CHECK dout0_17 Vdout0_17ck61 = 1.8 time = 620
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=620.05n

* CHECK dout0_18 Vdout0_18ck61 = 0 time = 620
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=620.05n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 620
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=620.05n

* CHECK dout0_20 Vdout0_20ck61 = 1.8 time = 620
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=620.05n

* CHECK dout0_21 Vdout0_21ck61 = 0 time = 620
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=620.05n

* CHECK dout0_22 Vdout0_22ck61 = 1.8 time = 620
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=620.05n

* CHECK dout0_23 Vdout0_23ck61 = 1.8 time = 620
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=620.05n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 620
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=620.05n

* CHECK dout0_25 Vdout0_25ck61 = 1.8 time = 620
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=620.05n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 620
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=620.05n

* CHECK dout0_27 Vdout0_27ck61 = 1.8 time = 620
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=620.05n

* CHECK dout0_28 Vdout0_28ck61 = 1.8 time = 620
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=620.05n

* CHECK dout0_29 Vdout0_29ck61 = 1.8 time = 620
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=620.05n

* CHECK dout0_30 Vdout0_30ck61 = 0 time = 620
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=620.05n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 620
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=620.05n

* CHECK dout1_0 Vdout1_0ck62 = 1.8 time = 630
.meas tran vdout1_0ck62 FIND v(dout1_0) AT=630.05n

* CHECK dout1_1 Vdout1_1ck62 = 0 time = 630
.meas tran vdout1_1ck62 FIND v(dout1_1) AT=630.05n

* CHECK dout1_2 Vdout1_2ck62 = 0 time = 630
.meas tran vdout1_2ck62 FIND v(dout1_2) AT=630.05n

* CHECK dout1_3 Vdout1_3ck62 = 0 time = 630
.meas tran vdout1_3ck62 FIND v(dout1_3) AT=630.05n

* CHECK dout1_4 Vdout1_4ck62 = 0 time = 630
.meas tran vdout1_4ck62 FIND v(dout1_4) AT=630.05n

* CHECK dout1_5 Vdout1_5ck62 = 1.8 time = 630
.meas tran vdout1_5ck62 FIND v(dout1_5) AT=630.05n

* CHECK dout1_6 Vdout1_6ck62 = 0 time = 630
.meas tran vdout1_6ck62 FIND v(dout1_6) AT=630.05n

* CHECK dout1_7 Vdout1_7ck62 = 0 time = 630
.meas tran vdout1_7ck62 FIND v(dout1_7) AT=630.05n

* CHECK dout1_8 Vdout1_8ck62 = 1.8 time = 630
.meas tran vdout1_8ck62 FIND v(dout1_8) AT=630.05n

* CHECK dout1_9 Vdout1_9ck62 = 1.8 time = 630
.meas tran vdout1_9ck62 FIND v(dout1_9) AT=630.05n

* CHECK dout1_10 Vdout1_10ck62 = 0 time = 630
.meas tran vdout1_10ck62 FIND v(dout1_10) AT=630.05n

* CHECK dout1_11 Vdout1_11ck62 = 0 time = 630
.meas tran vdout1_11ck62 FIND v(dout1_11) AT=630.05n

* CHECK dout1_12 Vdout1_12ck62 = 0 time = 630
.meas tran vdout1_12ck62 FIND v(dout1_12) AT=630.05n

* CHECK dout1_13 Vdout1_13ck62 = 0 time = 630
.meas tran vdout1_13ck62 FIND v(dout1_13) AT=630.05n

* CHECK dout1_14 Vdout1_14ck62 = 1.8 time = 630
.meas tran vdout1_14ck62 FIND v(dout1_14) AT=630.05n

* CHECK dout1_15 Vdout1_15ck62 = 0 time = 630
.meas tran vdout1_15ck62 FIND v(dout1_15) AT=630.05n

* CHECK dout1_16 Vdout1_16ck62 = 1.8 time = 630
.meas tran vdout1_16ck62 FIND v(dout1_16) AT=630.05n

* CHECK dout1_17 Vdout1_17ck62 = 1.8 time = 630
.meas tran vdout1_17ck62 FIND v(dout1_17) AT=630.05n

* CHECK dout1_18 Vdout1_18ck62 = 1.8 time = 630
.meas tran vdout1_18ck62 FIND v(dout1_18) AT=630.05n

* CHECK dout1_19 Vdout1_19ck62 = 1.8 time = 630
.meas tran vdout1_19ck62 FIND v(dout1_19) AT=630.05n

* CHECK dout1_20 Vdout1_20ck62 = 0 time = 630
.meas tran vdout1_20ck62 FIND v(dout1_20) AT=630.05n

* CHECK dout1_21 Vdout1_21ck62 = 0 time = 630
.meas tran vdout1_21ck62 FIND v(dout1_21) AT=630.05n

* CHECK dout1_22 Vdout1_22ck62 = 1.8 time = 630
.meas tran vdout1_22ck62 FIND v(dout1_22) AT=630.05n

* CHECK dout1_23 Vdout1_23ck62 = 0 time = 630
.meas tran vdout1_23ck62 FIND v(dout1_23) AT=630.05n

* CHECK dout1_24 Vdout1_24ck62 = 0 time = 630
.meas tran vdout1_24ck62 FIND v(dout1_24) AT=630.05n

* CHECK dout1_25 Vdout1_25ck62 = 1.8 time = 630
.meas tran vdout1_25ck62 FIND v(dout1_25) AT=630.05n

* CHECK dout1_26 Vdout1_26ck62 = 1.8 time = 630
.meas tran vdout1_26ck62 FIND v(dout1_26) AT=630.05n

* CHECK dout1_27 Vdout1_27ck62 = 0 time = 630
.meas tran vdout1_27ck62 FIND v(dout1_27) AT=630.05n

* CHECK dout1_28 Vdout1_28ck62 = 1.8 time = 630
.meas tran vdout1_28ck62 FIND v(dout1_28) AT=630.05n

* CHECK dout1_29 Vdout1_29ck62 = 0 time = 630
.meas tran vdout1_29ck62 FIND v(dout1_29) AT=630.05n

* CHECK dout1_30 Vdout1_30ck62 = 1.8 time = 630
.meas tran vdout1_30ck62 FIND v(dout1_30) AT=630.05n

* CHECK dout1_31 Vdout1_31ck62 = 1.8 time = 630
.meas tran vdout1_31ck62 FIND v(dout1_31) AT=630.05n

* CHECK dout1_0 Vdout1_0ck63 = 0 time = 640
.meas tran vdout1_0ck63 FIND v(dout1_0) AT=640.05n

* CHECK dout1_1 Vdout1_1ck63 = 0 time = 640
.meas tran vdout1_1ck63 FIND v(dout1_1) AT=640.05n

* CHECK dout1_2 Vdout1_2ck63 = 1.8 time = 640
.meas tran vdout1_2ck63 FIND v(dout1_2) AT=640.05n

* CHECK dout1_3 Vdout1_3ck63 = 0 time = 640
.meas tran vdout1_3ck63 FIND v(dout1_3) AT=640.05n

* CHECK dout1_4 Vdout1_4ck63 = 0 time = 640
.meas tran vdout1_4ck63 FIND v(dout1_4) AT=640.05n

* CHECK dout1_5 Vdout1_5ck63 = 1.8 time = 640
.meas tran vdout1_5ck63 FIND v(dout1_5) AT=640.05n

* CHECK dout1_6 Vdout1_6ck63 = 0 time = 640
.meas tran vdout1_6ck63 FIND v(dout1_6) AT=640.05n

* CHECK dout1_7 Vdout1_7ck63 = 1.8 time = 640
.meas tran vdout1_7ck63 FIND v(dout1_7) AT=640.05n

* CHECK dout1_8 Vdout1_8ck63 = 0 time = 640
.meas tran vdout1_8ck63 FIND v(dout1_8) AT=640.05n

* CHECK dout1_9 Vdout1_9ck63 = 1.8 time = 640
.meas tran vdout1_9ck63 FIND v(dout1_9) AT=640.05n

* CHECK dout1_10 Vdout1_10ck63 = 0 time = 640
.meas tran vdout1_10ck63 FIND v(dout1_10) AT=640.05n

* CHECK dout1_11 Vdout1_11ck63 = 1.8 time = 640
.meas tran vdout1_11ck63 FIND v(dout1_11) AT=640.05n

* CHECK dout1_12 Vdout1_12ck63 = 1.8 time = 640
.meas tran vdout1_12ck63 FIND v(dout1_12) AT=640.05n

* CHECK dout1_13 Vdout1_13ck63 = 0 time = 640
.meas tran vdout1_13ck63 FIND v(dout1_13) AT=640.05n

* CHECK dout1_14 Vdout1_14ck63 = 0 time = 640
.meas tran vdout1_14ck63 FIND v(dout1_14) AT=640.05n

* CHECK dout1_15 Vdout1_15ck63 = 0 time = 640
.meas tran vdout1_15ck63 FIND v(dout1_15) AT=640.05n

* CHECK dout1_16 Vdout1_16ck63 = 1.8 time = 640
.meas tran vdout1_16ck63 FIND v(dout1_16) AT=640.05n

* CHECK dout1_17 Vdout1_17ck63 = 1.8 time = 640
.meas tran vdout1_17ck63 FIND v(dout1_17) AT=640.05n

* CHECK dout1_18 Vdout1_18ck63 = 1.8 time = 640
.meas tran vdout1_18ck63 FIND v(dout1_18) AT=640.05n

* CHECK dout1_19 Vdout1_19ck63 = 0 time = 640
.meas tran vdout1_19ck63 FIND v(dout1_19) AT=640.05n

* CHECK dout1_20 Vdout1_20ck63 = 1.8 time = 640
.meas tran vdout1_20ck63 FIND v(dout1_20) AT=640.05n

* CHECK dout1_21 Vdout1_21ck63 = 1.8 time = 640
.meas tran vdout1_21ck63 FIND v(dout1_21) AT=640.05n

* CHECK dout1_22 Vdout1_22ck63 = 1.8 time = 640
.meas tran vdout1_22ck63 FIND v(dout1_22) AT=640.05n

* CHECK dout1_23 Vdout1_23ck63 = 1.8 time = 640
.meas tran vdout1_23ck63 FIND v(dout1_23) AT=640.05n

* CHECK dout1_24 Vdout1_24ck63 = 0 time = 640
.meas tran vdout1_24ck63 FIND v(dout1_24) AT=640.05n

* CHECK dout1_25 Vdout1_25ck63 = 0 time = 640
.meas tran vdout1_25ck63 FIND v(dout1_25) AT=640.05n

* CHECK dout1_26 Vdout1_26ck63 = 0 time = 640
.meas tran vdout1_26ck63 FIND v(dout1_26) AT=640.05n

* CHECK dout1_27 Vdout1_27ck63 = 1.8 time = 640
.meas tran vdout1_27ck63 FIND v(dout1_27) AT=640.05n

* CHECK dout1_28 Vdout1_28ck63 = 1.8 time = 640
.meas tran vdout1_28ck63 FIND v(dout1_28) AT=640.05n

* CHECK dout1_29 Vdout1_29ck63 = 0 time = 640
.meas tran vdout1_29ck63 FIND v(dout1_29) AT=640.05n

* CHECK dout1_30 Vdout1_30ck63 = 0 time = 640
.meas tran vdout1_30ck63 FIND v(dout1_30) AT=640.05n

* CHECK dout1_31 Vdout1_31ck63 = 1.8 time = 640
.meas tran vdout1_31ck63 FIND v(dout1_31) AT=640.05n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 0 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 1.8 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 0 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_8 Vdout0_8ck64 = 0 time = 650
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=650.05n

* CHECK dout0_9 Vdout0_9ck64 = 1.8 time = 650
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=650.05n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 650
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=650.05n

* CHECK dout0_11 Vdout0_11ck64 = 1.8 time = 650
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=650.05n

* CHECK dout0_12 Vdout0_12ck64 = 1.8 time = 650
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=650.05n

* CHECK dout0_13 Vdout0_13ck64 = 1.8 time = 650
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=650.05n

* CHECK dout0_14 Vdout0_14ck64 = 1.8 time = 650
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=650.05n

* CHECK dout0_15 Vdout0_15ck64 = 1.8 time = 650
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=650.05n

* CHECK dout0_16 Vdout0_16ck64 = 1.8 time = 650
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=650.05n

* CHECK dout0_17 Vdout0_17ck64 = 1.8 time = 650
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=650.05n

* CHECK dout0_18 Vdout0_18ck64 = 1.8 time = 650
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=650.05n

* CHECK dout0_19 Vdout0_19ck64 = 1.8 time = 650
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=650.05n

* CHECK dout0_20 Vdout0_20ck64 = 1.8 time = 650
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=650.05n

* CHECK dout0_21 Vdout0_21ck64 = 1.8 time = 650
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=650.05n

* CHECK dout0_22 Vdout0_22ck64 = 1.8 time = 650
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=650.05n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 650
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=650.05n

* CHECK dout0_24 Vdout0_24ck64 = 0 time = 650
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=650.05n

* CHECK dout0_25 Vdout0_25ck64 = 1.8 time = 650
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=650.05n

* CHECK dout0_26 Vdout0_26ck64 = 1.8 time = 650
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=650.05n

* CHECK dout0_27 Vdout0_27ck64 = 0 time = 650
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=650.05n

* CHECK dout0_28 Vdout0_28ck64 = 1.8 time = 650
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=650.05n

* CHECK dout0_29 Vdout0_29ck64 = 0 time = 650
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=650.05n

* CHECK dout0_30 Vdout0_30ck64 = 1.8 time = 650
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=650.05n

* CHECK dout0_31 Vdout0_31ck64 = 1.8 time = 650
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=650.05n

* CHECK dout1_0 Vdout1_0ck64 = 1.8 time = 650
.meas tran vdout1_0ck64 FIND v(dout1_0) AT=650.05n

* CHECK dout1_1 Vdout1_1ck64 = 1.8 time = 650
.meas tran vdout1_1ck64 FIND v(dout1_1) AT=650.05n

* CHECK dout1_2 Vdout1_2ck64 = 0 time = 650
.meas tran vdout1_2ck64 FIND v(dout1_2) AT=650.05n

* CHECK dout1_3 Vdout1_3ck64 = 1.8 time = 650
.meas tran vdout1_3ck64 FIND v(dout1_3) AT=650.05n

* CHECK dout1_4 Vdout1_4ck64 = 0 time = 650
.meas tran vdout1_4ck64 FIND v(dout1_4) AT=650.05n

* CHECK dout1_5 Vdout1_5ck64 = 0 time = 650
.meas tran vdout1_5ck64 FIND v(dout1_5) AT=650.05n

* CHECK dout1_6 Vdout1_6ck64 = 1.8 time = 650
.meas tran vdout1_6ck64 FIND v(dout1_6) AT=650.05n

* CHECK dout1_7 Vdout1_7ck64 = 0 time = 650
.meas tran vdout1_7ck64 FIND v(dout1_7) AT=650.05n

* CHECK dout1_8 Vdout1_8ck64 = 0 time = 650
.meas tran vdout1_8ck64 FIND v(dout1_8) AT=650.05n

* CHECK dout1_9 Vdout1_9ck64 = 1.8 time = 650
.meas tran vdout1_9ck64 FIND v(dout1_9) AT=650.05n

* CHECK dout1_10 Vdout1_10ck64 = 1.8 time = 650
.meas tran vdout1_10ck64 FIND v(dout1_10) AT=650.05n

* CHECK dout1_11 Vdout1_11ck64 = 1.8 time = 650
.meas tran vdout1_11ck64 FIND v(dout1_11) AT=650.05n

* CHECK dout1_12 Vdout1_12ck64 = 1.8 time = 650
.meas tran vdout1_12ck64 FIND v(dout1_12) AT=650.05n

* CHECK dout1_13 Vdout1_13ck64 = 0 time = 650
.meas tran vdout1_13ck64 FIND v(dout1_13) AT=650.05n

* CHECK dout1_14 Vdout1_14ck64 = 0 time = 650
.meas tran vdout1_14ck64 FIND v(dout1_14) AT=650.05n

* CHECK dout1_15 Vdout1_15ck64 = 0 time = 650
.meas tran vdout1_15ck64 FIND v(dout1_15) AT=650.05n

* CHECK dout1_16 Vdout1_16ck64 = 1.8 time = 650
.meas tran vdout1_16ck64 FIND v(dout1_16) AT=650.05n

* CHECK dout1_17 Vdout1_17ck64 = 1.8 time = 650
.meas tran vdout1_17ck64 FIND v(dout1_17) AT=650.05n

* CHECK dout1_18 Vdout1_18ck64 = 0 time = 650
.meas tran vdout1_18ck64 FIND v(dout1_18) AT=650.05n

* CHECK dout1_19 Vdout1_19ck64 = 0 time = 650
.meas tran vdout1_19ck64 FIND v(dout1_19) AT=650.05n

* CHECK dout1_20 Vdout1_20ck64 = 1.8 time = 650
.meas tran vdout1_20ck64 FIND v(dout1_20) AT=650.05n

* CHECK dout1_21 Vdout1_21ck64 = 0 time = 650
.meas tran vdout1_21ck64 FIND v(dout1_21) AT=650.05n

* CHECK dout1_22 Vdout1_22ck64 = 1.8 time = 650
.meas tran vdout1_22ck64 FIND v(dout1_22) AT=650.05n

* CHECK dout1_23 Vdout1_23ck64 = 1.8 time = 650
.meas tran vdout1_23ck64 FIND v(dout1_23) AT=650.05n

* CHECK dout1_24 Vdout1_24ck64 = 0 time = 650
.meas tran vdout1_24ck64 FIND v(dout1_24) AT=650.05n

* CHECK dout1_25 Vdout1_25ck64 = 1.8 time = 650
.meas tran vdout1_25ck64 FIND v(dout1_25) AT=650.05n

* CHECK dout1_26 Vdout1_26ck64 = 0 time = 650
.meas tran vdout1_26ck64 FIND v(dout1_26) AT=650.05n

* CHECK dout1_27 Vdout1_27ck64 = 1.8 time = 650
.meas tran vdout1_27ck64 FIND v(dout1_27) AT=650.05n

* CHECK dout1_28 Vdout1_28ck64 = 1.8 time = 650
.meas tran vdout1_28ck64 FIND v(dout1_28) AT=650.05n

* CHECK dout1_29 Vdout1_29ck64 = 1.8 time = 650
.meas tran vdout1_29ck64 FIND v(dout1_29) AT=650.05n

* CHECK dout1_30 Vdout1_30ck64 = 0 time = 650
.meas tran vdout1_30ck64 FIND v(dout1_30) AT=650.05n

* CHECK dout1_31 Vdout1_31ck64 = 0 time = 650
.meas tran vdout1_31ck64 FIND v(dout1_31) AT=650.05n

* CHECK dout1_0 Vdout1_0ck65 = 1.8 time = 660
.meas tran vdout1_0ck65 FIND v(dout1_0) AT=660.05n

* CHECK dout1_1 Vdout1_1ck65 = 0 time = 660
.meas tran vdout1_1ck65 FIND v(dout1_1) AT=660.05n

* CHECK dout1_2 Vdout1_2ck65 = 0 time = 660
.meas tran vdout1_2ck65 FIND v(dout1_2) AT=660.05n

* CHECK dout1_3 Vdout1_3ck65 = 0 time = 660
.meas tran vdout1_3ck65 FIND v(dout1_3) AT=660.05n

* CHECK dout1_4 Vdout1_4ck65 = 0 time = 660
.meas tran vdout1_4ck65 FIND v(dout1_4) AT=660.05n

* CHECK dout1_5 Vdout1_5ck65 = 1.8 time = 660
.meas tran vdout1_5ck65 FIND v(dout1_5) AT=660.05n

* CHECK dout1_6 Vdout1_6ck65 = 0 time = 660
.meas tran vdout1_6ck65 FIND v(dout1_6) AT=660.05n

* CHECK dout1_7 Vdout1_7ck65 = 0 time = 660
.meas tran vdout1_7ck65 FIND v(dout1_7) AT=660.05n

* CHECK dout1_8 Vdout1_8ck65 = 0 time = 660
.meas tran vdout1_8ck65 FIND v(dout1_8) AT=660.05n

* CHECK dout1_9 Vdout1_9ck65 = 1.8 time = 660
.meas tran vdout1_9ck65 FIND v(dout1_9) AT=660.05n

* CHECK dout1_10 Vdout1_10ck65 = 0 time = 660
.meas tran vdout1_10ck65 FIND v(dout1_10) AT=660.05n

* CHECK dout1_11 Vdout1_11ck65 = 1.8 time = 660
.meas tran vdout1_11ck65 FIND v(dout1_11) AT=660.05n

* CHECK dout1_12 Vdout1_12ck65 = 1.8 time = 660
.meas tran vdout1_12ck65 FIND v(dout1_12) AT=660.05n

* CHECK dout1_13 Vdout1_13ck65 = 1.8 time = 660
.meas tran vdout1_13ck65 FIND v(dout1_13) AT=660.05n

* CHECK dout1_14 Vdout1_14ck65 = 1.8 time = 660
.meas tran vdout1_14ck65 FIND v(dout1_14) AT=660.05n

* CHECK dout1_15 Vdout1_15ck65 = 1.8 time = 660
.meas tran vdout1_15ck65 FIND v(dout1_15) AT=660.05n

* CHECK dout1_16 Vdout1_16ck65 = 1.8 time = 660
.meas tran vdout1_16ck65 FIND v(dout1_16) AT=660.05n

* CHECK dout1_17 Vdout1_17ck65 = 1.8 time = 660
.meas tran vdout1_17ck65 FIND v(dout1_17) AT=660.05n

* CHECK dout1_18 Vdout1_18ck65 = 1.8 time = 660
.meas tran vdout1_18ck65 FIND v(dout1_18) AT=660.05n

* CHECK dout1_19 Vdout1_19ck65 = 1.8 time = 660
.meas tran vdout1_19ck65 FIND v(dout1_19) AT=660.05n

* CHECK dout1_20 Vdout1_20ck65 = 1.8 time = 660
.meas tran vdout1_20ck65 FIND v(dout1_20) AT=660.05n

* CHECK dout1_21 Vdout1_21ck65 = 1.8 time = 660
.meas tran vdout1_21ck65 FIND v(dout1_21) AT=660.05n

* CHECK dout1_22 Vdout1_22ck65 = 1.8 time = 660
.meas tran vdout1_22ck65 FIND v(dout1_22) AT=660.05n

* CHECK dout1_23 Vdout1_23ck65 = 0 time = 660
.meas tran vdout1_23ck65 FIND v(dout1_23) AT=660.05n

* CHECK dout1_24 Vdout1_24ck65 = 0 time = 660
.meas tran vdout1_24ck65 FIND v(dout1_24) AT=660.05n

* CHECK dout1_25 Vdout1_25ck65 = 1.8 time = 660
.meas tran vdout1_25ck65 FIND v(dout1_25) AT=660.05n

* CHECK dout1_26 Vdout1_26ck65 = 1.8 time = 660
.meas tran vdout1_26ck65 FIND v(dout1_26) AT=660.05n

* CHECK dout1_27 Vdout1_27ck65 = 0 time = 660
.meas tran vdout1_27ck65 FIND v(dout1_27) AT=660.05n

* CHECK dout1_28 Vdout1_28ck65 = 1.8 time = 660
.meas tran vdout1_28ck65 FIND v(dout1_28) AT=660.05n

* CHECK dout1_29 Vdout1_29ck65 = 0 time = 660
.meas tran vdout1_29ck65 FIND v(dout1_29) AT=660.05n

* CHECK dout1_30 Vdout1_30ck65 = 1.8 time = 660
.meas tran vdout1_30ck65 FIND v(dout1_30) AT=660.05n

* CHECK dout1_31 Vdout1_31ck65 = 1.8 time = 660
.meas tran vdout1_31ck65 FIND v(dout1_31) AT=660.05n

* CHECK dout1_0 Vdout1_0ck67 = 1.8 time = 680
.meas tran vdout1_0ck67 FIND v(dout1_0) AT=680.05n

* CHECK dout1_1 Vdout1_1ck67 = 1.8 time = 680
.meas tran vdout1_1ck67 FIND v(dout1_1) AT=680.05n

* CHECK dout1_2 Vdout1_2ck67 = 1.8 time = 680
.meas tran vdout1_2ck67 FIND v(dout1_2) AT=680.05n

* CHECK dout1_3 Vdout1_3ck67 = 0 time = 680
.meas tran vdout1_3ck67 FIND v(dout1_3) AT=680.05n

* CHECK dout1_4 Vdout1_4ck67 = 1.8 time = 680
.meas tran vdout1_4ck67 FIND v(dout1_4) AT=680.05n

* CHECK dout1_5 Vdout1_5ck67 = 1.8 time = 680
.meas tran vdout1_5ck67 FIND v(dout1_5) AT=680.05n

* CHECK dout1_6 Vdout1_6ck67 = 1.8 time = 680
.meas tran vdout1_6ck67 FIND v(dout1_6) AT=680.05n

* CHECK dout1_7 Vdout1_7ck67 = 1.8 time = 680
.meas tran vdout1_7ck67 FIND v(dout1_7) AT=680.05n

* CHECK dout1_8 Vdout1_8ck67 = 0 time = 680
.meas tran vdout1_8ck67 FIND v(dout1_8) AT=680.05n

* CHECK dout1_9 Vdout1_9ck67 = 0 time = 680
.meas tran vdout1_9ck67 FIND v(dout1_9) AT=680.05n

* CHECK dout1_10 Vdout1_10ck67 = 1.8 time = 680
.meas tran vdout1_10ck67 FIND v(dout1_10) AT=680.05n

* CHECK dout1_11 Vdout1_11ck67 = 0 time = 680
.meas tran vdout1_11ck67 FIND v(dout1_11) AT=680.05n

* CHECK dout1_12 Vdout1_12ck67 = 1.8 time = 680
.meas tran vdout1_12ck67 FIND v(dout1_12) AT=680.05n

* CHECK dout1_13 Vdout1_13ck67 = 0 time = 680
.meas tran vdout1_13ck67 FIND v(dout1_13) AT=680.05n

* CHECK dout1_14 Vdout1_14ck67 = 1.8 time = 680
.meas tran vdout1_14ck67 FIND v(dout1_14) AT=680.05n

* CHECK dout1_15 Vdout1_15ck67 = 1.8 time = 680
.meas tran vdout1_15ck67 FIND v(dout1_15) AT=680.05n

* CHECK dout1_16 Vdout1_16ck67 = 1.8 time = 680
.meas tran vdout1_16ck67 FIND v(dout1_16) AT=680.05n

* CHECK dout1_17 Vdout1_17ck67 = 0 time = 680
.meas tran vdout1_17ck67 FIND v(dout1_17) AT=680.05n

* CHECK dout1_18 Vdout1_18ck67 = 1.8 time = 680
.meas tran vdout1_18ck67 FIND v(dout1_18) AT=680.05n

* CHECK dout1_19 Vdout1_19ck67 = 0 time = 680
.meas tran vdout1_19ck67 FIND v(dout1_19) AT=680.05n

* CHECK dout1_20 Vdout1_20ck67 = 1.8 time = 680
.meas tran vdout1_20ck67 FIND v(dout1_20) AT=680.05n

* CHECK dout1_21 Vdout1_21ck67 = 1.8 time = 680
.meas tran vdout1_21ck67 FIND v(dout1_21) AT=680.05n

* CHECK dout1_22 Vdout1_22ck67 = 1.8 time = 680
.meas tran vdout1_22ck67 FIND v(dout1_22) AT=680.05n

* CHECK dout1_23 Vdout1_23ck67 = 0 time = 680
.meas tran vdout1_23ck67 FIND v(dout1_23) AT=680.05n

* CHECK dout1_24 Vdout1_24ck67 = 0 time = 680
.meas tran vdout1_24ck67 FIND v(dout1_24) AT=680.05n

* CHECK dout1_25 Vdout1_25ck67 = 1.8 time = 680
.meas tran vdout1_25ck67 FIND v(dout1_25) AT=680.05n

* CHECK dout1_26 Vdout1_26ck67 = 0 time = 680
.meas tran vdout1_26ck67 FIND v(dout1_26) AT=680.05n

* CHECK dout1_27 Vdout1_27ck67 = 1.8 time = 680
.meas tran vdout1_27ck67 FIND v(dout1_27) AT=680.05n

* CHECK dout1_28 Vdout1_28ck67 = 0 time = 680
.meas tran vdout1_28ck67 FIND v(dout1_28) AT=680.05n

* CHECK dout1_29 Vdout1_29ck67 = 1.8 time = 680
.meas tran vdout1_29ck67 FIND v(dout1_29) AT=680.05n

* CHECK dout1_30 Vdout1_30ck67 = 1.8 time = 680
.meas tran vdout1_30ck67 FIND v(dout1_30) AT=680.05n

* CHECK dout1_31 Vdout1_31ck67 = 0 time = 680
.meas tran vdout1_31ck67 FIND v(dout1_31) AT=680.05n

* CHECK dout0_0 Vdout0_0ck68 = 0 time = 690
.meas tran vdout0_0ck68 FIND v(dout0_0) AT=690.05n

* CHECK dout0_1 Vdout0_1ck68 = 0 time = 690
.meas tran vdout0_1ck68 FIND v(dout0_1) AT=690.05n

* CHECK dout0_2 Vdout0_2ck68 = 1.8 time = 690
.meas tran vdout0_2ck68 FIND v(dout0_2) AT=690.05n

* CHECK dout0_3 Vdout0_3ck68 = 0 time = 690
.meas tran vdout0_3ck68 FIND v(dout0_3) AT=690.05n

* CHECK dout0_4 Vdout0_4ck68 = 0 time = 690
.meas tran vdout0_4ck68 FIND v(dout0_4) AT=690.05n

* CHECK dout0_5 Vdout0_5ck68 = 1.8 time = 690
.meas tran vdout0_5ck68 FIND v(dout0_5) AT=690.05n

* CHECK dout0_6 Vdout0_6ck68 = 0 time = 690
.meas tran vdout0_6ck68 FIND v(dout0_6) AT=690.05n

* CHECK dout0_7 Vdout0_7ck68 = 1.8 time = 690
.meas tran vdout0_7ck68 FIND v(dout0_7) AT=690.05n

* CHECK dout0_8 Vdout0_8ck68 = 1.8 time = 690
.meas tran vdout0_8ck68 FIND v(dout0_8) AT=690.05n

* CHECK dout0_9 Vdout0_9ck68 = 0 time = 690
.meas tran vdout0_9ck68 FIND v(dout0_9) AT=690.05n

* CHECK dout0_10 Vdout0_10ck68 = 0 time = 690
.meas tran vdout0_10ck68 FIND v(dout0_10) AT=690.05n

* CHECK dout0_11 Vdout0_11ck68 = 1.8 time = 690
.meas tran vdout0_11ck68 FIND v(dout0_11) AT=690.05n

* CHECK dout0_12 Vdout0_12ck68 = 0 time = 690
.meas tran vdout0_12ck68 FIND v(dout0_12) AT=690.05n

* CHECK dout0_13 Vdout0_13ck68 = 1.8 time = 690
.meas tran vdout0_13ck68 FIND v(dout0_13) AT=690.05n

* CHECK dout0_14 Vdout0_14ck68 = 1.8 time = 690
.meas tran vdout0_14ck68 FIND v(dout0_14) AT=690.05n

* CHECK dout0_15 Vdout0_15ck68 = 0 time = 690
.meas tran vdout0_15ck68 FIND v(dout0_15) AT=690.05n

* CHECK dout0_16 Vdout0_16ck68 = 0 time = 690
.meas tran vdout0_16ck68 FIND v(dout0_16) AT=690.05n

* CHECK dout0_17 Vdout0_17ck68 = 0 time = 690
.meas tran vdout0_17ck68 FIND v(dout0_17) AT=690.05n

* CHECK dout0_18 Vdout0_18ck68 = 1.8 time = 690
.meas tran vdout0_18ck68 FIND v(dout0_18) AT=690.05n

* CHECK dout0_19 Vdout0_19ck68 = 0 time = 690
.meas tran vdout0_19ck68 FIND v(dout0_19) AT=690.05n

* CHECK dout0_20 Vdout0_20ck68 = 0 time = 690
.meas tran vdout0_20ck68 FIND v(dout0_20) AT=690.05n

* CHECK dout0_21 Vdout0_21ck68 = 1.8 time = 690
.meas tran vdout0_21ck68 FIND v(dout0_21) AT=690.05n

* CHECK dout0_22 Vdout0_22ck68 = 0 time = 690
.meas tran vdout0_22ck68 FIND v(dout0_22) AT=690.05n

* CHECK dout0_23 Vdout0_23ck68 = 0 time = 690
.meas tran vdout0_23ck68 FIND v(dout0_23) AT=690.05n

* CHECK dout0_24 Vdout0_24ck68 = 0 time = 690
.meas tran vdout0_24ck68 FIND v(dout0_24) AT=690.05n

* CHECK dout0_25 Vdout0_25ck68 = 0 time = 690
.meas tran vdout0_25ck68 FIND v(dout0_25) AT=690.05n

* CHECK dout0_26 Vdout0_26ck68 = 0 time = 690
.meas tran vdout0_26ck68 FIND v(dout0_26) AT=690.05n

* CHECK dout0_27 Vdout0_27ck68 = 1.8 time = 690
.meas tran vdout0_27ck68 FIND v(dout0_27) AT=690.05n

* CHECK dout0_28 Vdout0_28ck68 = 1.8 time = 690
.meas tran vdout0_28ck68 FIND v(dout0_28) AT=690.05n

* CHECK dout0_29 Vdout0_29ck68 = 0 time = 690
.meas tran vdout0_29ck68 FIND v(dout0_29) AT=690.05n

* CHECK dout0_30 Vdout0_30ck68 = 0 time = 690
.meas tran vdout0_30ck68 FIND v(dout0_30) AT=690.05n

* CHECK dout0_31 Vdout0_31ck68 = 1.8 time = 690
.meas tran vdout0_31ck68 FIND v(dout0_31) AT=690.05n

* CHECK dout1_0 Vdout1_0ck68 = 1.8 time = 690
.meas tran vdout1_0ck68 FIND v(dout1_0) AT=690.05n

* CHECK dout1_1 Vdout1_1ck68 = 0 time = 690
.meas tran vdout1_1ck68 FIND v(dout1_1) AT=690.05n

* CHECK dout1_2 Vdout1_2ck68 = 1.8 time = 690
.meas tran vdout1_2ck68 FIND v(dout1_2) AT=690.05n

* CHECK dout1_3 Vdout1_3ck68 = 1.8 time = 690
.meas tran vdout1_3ck68 FIND v(dout1_3) AT=690.05n

* CHECK dout1_4 Vdout1_4ck68 = 0 time = 690
.meas tran vdout1_4ck68 FIND v(dout1_4) AT=690.05n

* CHECK dout1_5 Vdout1_5ck68 = 0 time = 690
.meas tran vdout1_5ck68 FIND v(dout1_5) AT=690.05n

* CHECK dout1_6 Vdout1_6ck68 = 1.8 time = 690
.meas tran vdout1_6ck68 FIND v(dout1_6) AT=690.05n

* CHECK dout1_7 Vdout1_7ck68 = 0 time = 690
.meas tran vdout1_7ck68 FIND v(dout1_7) AT=690.05n

* CHECK dout1_8 Vdout1_8ck68 = 1.8 time = 690
.meas tran vdout1_8ck68 FIND v(dout1_8) AT=690.05n

* CHECK dout1_9 Vdout1_9ck68 = 1.8 time = 690
.meas tran vdout1_9ck68 FIND v(dout1_9) AT=690.05n

* CHECK dout1_10 Vdout1_10ck68 = 1.8 time = 690
.meas tran vdout1_10ck68 FIND v(dout1_10) AT=690.05n

* CHECK dout1_11 Vdout1_11ck68 = 0 time = 690
.meas tran vdout1_11ck68 FIND v(dout1_11) AT=690.05n

* CHECK dout1_12 Vdout1_12ck68 = 1.8 time = 690
.meas tran vdout1_12ck68 FIND v(dout1_12) AT=690.05n

* CHECK dout1_13 Vdout1_13ck68 = 1.8 time = 690
.meas tran vdout1_13ck68 FIND v(dout1_13) AT=690.05n

* CHECK dout1_14 Vdout1_14ck68 = 0 time = 690
.meas tran vdout1_14ck68 FIND v(dout1_14) AT=690.05n

* CHECK dout1_15 Vdout1_15ck68 = 0 time = 690
.meas tran vdout1_15ck68 FIND v(dout1_15) AT=690.05n

* CHECK dout1_16 Vdout1_16ck68 = 1.8 time = 690
.meas tran vdout1_16ck68 FIND v(dout1_16) AT=690.05n

* CHECK dout1_17 Vdout1_17ck68 = 0 time = 690
.meas tran vdout1_17ck68 FIND v(dout1_17) AT=690.05n

* CHECK dout1_18 Vdout1_18ck68 = 1.8 time = 690
.meas tran vdout1_18ck68 FIND v(dout1_18) AT=690.05n

* CHECK dout1_19 Vdout1_19ck68 = 0 time = 690
.meas tran vdout1_19ck68 FIND v(dout1_19) AT=690.05n

* CHECK dout1_20 Vdout1_20ck68 = 0 time = 690
.meas tran vdout1_20ck68 FIND v(dout1_20) AT=690.05n

* CHECK dout1_21 Vdout1_21ck68 = 1.8 time = 690
.meas tran vdout1_21ck68 FIND v(dout1_21) AT=690.05n

* CHECK dout1_22 Vdout1_22ck68 = 0 time = 690
.meas tran vdout1_22ck68 FIND v(dout1_22) AT=690.05n

* CHECK dout1_23 Vdout1_23ck68 = 1.8 time = 690
.meas tran vdout1_23ck68 FIND v(dout1_23) AT=690.05n

* CHECK dout1_24 Vdout1_24ck68 = 0 time = 690
.meas tran vdout1_24ck68 FIND v(dout1_24) AT=690.05n

* CHECK dout1_25 Vdout1_25ck68 = 1.8 time = 690
.meas tran vdout1_25ck68 FIND v(dout1_25) AT=690.05n

* CHECK dout1_26 Vdout1_26ck68 = 0 time = 690
.meas tran vdout1_26ck68 FIND v(dout1_26) AT=690.05n

* CHECK dout1_27 Vdout1_27ck68 = 0 time = 690
.meas tran vdout1_27ck68 FIND v(dout1_27) AT=690.05n

* CHECK dout1_28 Vdout1_28ck68 = 0 time = 690
.meas tran vdout1_28ck68 FIND v(dout1_28) AT=690.05n

* CHECK dout1_29 Vdout1_29ck68 = 1.8 time = 690
.meas tran vdout1_29ck68 FIND v(dout1_29) AT=690.05n

* CHECK dout1_30 Vdout1_30ck68 = 1.8 time = 690
.meas tran vdout1_30ck68 FIND v(dout1_30) AT=690.05n

* CHECK dout1_31 Vdout1_31ck68 = 1.8 time = 690
.meas tran vdout1_31ck68 FIND v(dout1_31) AT=690.05n

* CHECK dout0_0 Vdout0_0ck69 = 0 time = 700
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=700.05n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 700
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=700.05n

* CHECK dout0_2 Vdout0_2ck69 = 1.8 time = 700
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=700.05n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 700
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=700.05n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 700
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=700.05n

* CHECK dout0_5 Vdout0_5ck69 = 1.8 time = 700
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=700.05n

* CHECK dout0_6 Vdout0_6ck69 = 0 time = 700
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=700.05n

* CHECK dout0_7 Vdout0_7ck69 = 1.8 time = 700
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=700.05n

* CHECK dout0_8 Vdout0_8ck69 = 1.8 time = 700
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=700.05n

* CHECK dout0_9 Vdout0_9ck69 = 0 time = 700
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=700.05n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 700
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=700.05n

* CHECK dout0_11 Vdout0_11ck69 = 1.8 time = 700
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=700.05n

* CHECK dout0_12 Vdout0_12ck69 = 0 time = 700
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=700.05n

* CHECK dout0_13 Vdout0_13ck69 = 1.8 time = 700
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=700.05n

* CHECK dout0_14 Vdout0_14ck69 = 1.8 time = 700
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=700.05n

* CHECK dout0_15 Vdout0_15ck69 = 0 time = 700
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=700.05n

* CHECK dout0_16 Vdout0_16ck69 = 0 time = 700
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=700.05n

* CHECK dout0_17 Vdout0_17ck69 = 0 time = 700
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=700.05n

* CHECK dout0_18 Vdout0_18ck69 = 1.8 time = 700
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=700.05n

* CHECK dout0_19 Vdout0_19ck69 = 0 time = 700
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=700.05n

* CHECK dout0_20 Vdout0_20ck69 = 0 time = 700
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=700.05n

* CHECK dout0_21 Vdout0_21ck69 = 1.8 time = 700
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=700.05n

* CHECK dout0_22 Vdout0_22ck69 = 0 time = 700
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=700.05n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 700
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=700.05n

* CHECK dout0_24 Vdout0_24ck69 = 0 time = 700
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=700.05n

* CHECK dout0_25 Vdout0_25ck69 = 0 time = 700
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=700.05n

* CHECK dout0_26 Vdout0_26ck69 = 0 time = 700
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=700.05n

* CHECK dout0_27 Vdout0_27ck69 = 1.8 time = 700
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=700.05n

* CHECK dout0_28 Vdout0_28ck69 = 1.8 time = 700
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=700.05n

* CHECK dout0_29 Vdout0_29ck69 = 0 time = 700
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=700.05n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 700
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=700.05n

* CHECK dout0_31 Vdout0_31ck69 = 1.8 time = 700
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=700.05n

* CHECK dout1_0 Vdout1_0ck70 = 1.8 time = 710
.meas tran vdout1_0ck70 FIND v(dout1_0) AT=710.05n

* CHECK dout1_1 Vdout1_1ck70 = 1.8 time = 710
.meas tran vdout1_1ck70 FIND v(dout1_1) AT=710.05n

* CHECK dout1_2 Vdout1_2ck70 = 1.8 time = 710
.meas tran vdout1_2ck70 FIND v(dout1_2) AT=710.05n

* CHECK dout1_3 Vdout1_3ck70 = 0 time = 710
.meas tran vdout1_3ck70 FIND v(dout1_3) AT=710.05n

* CHECK dout1_4 Vdout1_4ck70 = 1.8 time = 710
.meas tran vdout1_4ck70 FIND v(dout1_4) AT=710.05n

* CHECK dout1_5 Vdout1_5ck70 = 1.8 time = 710
.meas tran vdout1_5ck70 FIND v(dout1_5) AT=710.05n

* CHECK dout1_6 Vdout1_6ck70 = 1.8 time = 710
.meas tran vdout1_6ck70 FIND v(dout1_6) AT=710.05n

* CHECK dout1_7 Vdout1_7ck70 = 1.8 time = 710
.meas tran vdout1_7ck70 FIND v(dout1_7) AT=710.05n

* CHECK dout1_8 Vdout1_8ck70 = 0 time = 710
.meas tran vdout1_8ck70 FIND v(dout1_8) AT=710.05n

* CHECK dout1_9 Vdout1_9ck70 = 0 time = 710
.meas tran vdout1_9ck70 FIND v(dout1_9) AT=710.05n

* CHECK dout1_10 Vdout1_10ck70 = 1.8 time = 710
.meas tran vdout1_10ck70 FIND v(dout1_10) AT=710.05n

* CHECK dout1_11 Vdout1_11ck70 = 0 time = 710
.meas tran vdout1_11ck70 FIND v(dout1_11) AT=710.05n

* CHECK dout1_12 Vdout1_12ck70 = 1.8 time = 710
.meas tran vdout1_12ck70 FIND v(dout1_12) AT=710.05n

* CHECK dout1_13 Vdout1_13ck70 = 0 time = 710
.meas tran vdout1_13ck70 FIND v(dout1_13) AT=710.05n

* CHECK dout1_14 Vdout1_14ck70 = 1.8 time = 710
.meas tran vdout1_14ck70 FIND v(dout1_14) AT=710.05n

* CHECK dout1_15 Vdout1_15ck70 = 1.8 time = 710
.meas tran vdout1_15ck70 FIND v(dout1_15) AT=710.05n

* CHECK dout1_16 Vdout1_16ck70 = 1.8 time = 710
.meas tran vdout1_16ck70 FIND v(dout1_16) AT=710.05n

* CHECK dout1_17 Vdout1_17ck70 = 0 time = 710
.meas tran vdout1_17ck70 FIND v(dout1_17) AT=710.05n

* CHECK dout1_18 Vdout1_18ck70 = 1.8 time = 710
.meas tran vdout1_18ck70 FIND v(dout1_18) AT=710.05n

* CHECK dout1_19 Vdout1_19ck70 = 0 time = 710
.meas tran vdout1_19ck70 FIND v(dout1_19) AT=710.05n

* CHECK dout1_20 Vdout1_20ck70 = 1.8 time = 710
.meas tran vdout1_20ck70 FIND v(dout1_20) AT=710.05n

* CHECK dout1_21 Vdout1_21ck70 = 1.8 time = 710
.meas tran vdout1_21ck70 FIND v(dout1_21) AT=710.05n

* CHECK dout1_22 Vdout1_22ck70 = 1.8 time = 710
.meas tran vdout1_22ck70 FIND v(dout1_22) AT=710.05n

* CHECK dout1_23 Vdout1_23ck70 = 0 time = 710
.meas tran vdout1_23ck70 FIND v(dout1_23) AT=710.05n

* CHECK dout1_24 Vdout1_24ck70 = 0 time = 710
.meas tran vdout1_24ck70 FIND v(dout1_24) AT=710.05n

* CHECK dout1_25 Vdout1_25ck70 = 1.8 time = 710
.meas tran vdout1_25ck70 FIND v(dout1_25) AT=710.05n

* CHECK dout1_26 Vdout1_26ck70 = 0 time = 710
.meas tran vdout1_26ck70 FIND v(dout1_26) AT=710.05n

* CHECK dout1_27 Vdout1_27ck70 = 1.8 time = 710
.meas tran vdout1_27ck70 FIND v(dout1_27) AT=710.05n

* CHECK dout1_28 Vdout1_28ck70 = 0 time = 710
.meas tran vdout1_28ck70 FIND v(dout1_28) AT=710.05n

* CHECK dout1_29 Vdout1_29ck70 = 1.8 time = 710
.meas tran vdout1_29ck70 FIND v(dout1_29) AT=710.05n

* CHECK dout1_30 Vdout1_30ck70 = 1.8 time = 710
.meas tran vdout1_30ck70 FIND v(dout1_30) AT=710.05n

* CHECK dout1_31 Vdout1_31ck70 = 0 time = 710
.meas tran vdout1_31ck70 FIND v(dout1_31) AT=710.05n

* CHECK dout1_0 Vdout1_0ck72 = 1.8 time = 730
.meas tran vdout1_0ck72 FIND v(dout1_0) AT=730.05n

* CHECK dout1_1 Vdout1_1ck72 = 1.8 time = 730
.meas tran vdout1_1ck72 FIND v(dout1_1) AT=730.05n

* CHECK dout1_2 Vdout1_2ck72 = 1.8 time = 730
.meas tran vdout1_2ck72 FIND v(dout1_2) AT=730.05n

* CHECK dout1_3 Vdout1_3ck72 = 0 time = 730
.meas tran vdout1_3ck72 FIND v(dout1_3) AT=730.05n

* CHECK dout1_4 Vdout1_4ck72 = 1.8 time = 730
.meas tran vdout1_4ck72 FIND v(dout1_4) AT=730.05n

* CHECK dout1_5 Vdout1_5ck72 = 1.8 time = 730
.meas tran vdout1_5ck72 FIND v(dout1_5) AT=730.05n

* CHECK dout1_6 Vdout1_6ck72 = 1.8 time = 730
.meas tran vdout1_6ck72 FIND v(dout1_6) AT=730.05n

* CHECK dout1_7 Vdout1_7ck72 = 1.8 time = 730
.meas tran vdout1_7ck72 FIND v(dout1_7) AT=730.05n

* CHECK dout1_8 Vdout1_8ck72 = 0 time = 730
.meas tran vdout1_8ck72 FIND v(dout1_8) AT=730.05n

* CHECK dout1_9 Vdout1_9ck72 = 0 time = 730
.meas tran vdout1_9ck72 FIND v(dout1_9) AT=730.05n

* CHECK dout1_10 Vdout1_10ck72 = 1.8 time = 730
.meas tran vdout1_10ck72 FIND v(dout1_10) AT=730.05n

* CHECK dout1_11 Vdout1_11ck72 = 0 time = 730
.meas tran vdout1_11ck72 FIND v(dout1_11) AT=730.05n

* CHECK dout1_12 Vdout1_12ck72 = 1.8 time = 730
.meas tran vdout1_12ck72 FIND v(dout1_12) AT=730.05n

* CHECK dout1_13 Vdout1_13ck72 = 0 time = 730
.meas tran vdout1_13ck72 FIND v(dout1_13) AT=730.05n

* CHECK dout1_14 Vdout1_14ck72 = 1.8 time = 730
.meas tran vdout1_14ck72 FIND v(dout1_14) AT=730.05n

* CHECK dout1_15 Vdout1_15ck72 = 1.8 time = 730
.meas tran vdout1_15ck72 FIND v(dout1_15) AT=730.05n

* CHECK dout1_16 Vdout1_16ck72 = 1.8 time = 730
.meas tran vdout1_16ck72 FIND v(dout1_16) AT=730.05n

* CHECK dout1_17 Vdout1_17ck72 = 0 time = 730
.meas tran vdout1_17ck72 FIND v(dout1_17) AT=730.05n

* CHECK dout1_18 Vdout1_18ck72 = 1.8 time = 730
.meas tran vdout1_18ck72 FIND v(dout1_18) AT=730.05n

* CHECK dout1_19 Vdout1_19ck72 = 0 time = 730
.meas tran vdout1_19ck72 FIND v(dout1_19) AT=730.05n

* CHECK dout1_20 Vdout1_20ck72 = 1.8 time = 730
.meas tran vdout1_20ck72 FIND v(dout1_20) AT=730.05n

* CHECK dout1_21 Vdout1_21ck72 = 1.8 time = 730
.meas tran vdout1_21ck72 FIND v(dout1_21) AT=730.05n

* CHECK dout1_22 Vdout1_22ck72 = 1.8 time = 730
.meas tran vdout1_22ck72 FIND v(dout1_22) AT=730.05n

* CHECK dout1_23 Vdout1_23ck72 = 0 time = 730
.meas tran vdout1_23ck72 FIND v(dout1_23) AT=730.05n

* CHECK dout1_24 Vdout1_24ck72 = 0 time = 730
.meas tran vdout1_24ck72 FIND v(dout1_24) AT=730.05n

* CHECK dout1_25 Vdout1_25ck72 = 1.8 time = 730
.meas tran vdout1_25ck72 FIND v(dout1_25) AT=730.05n

* CHECK dout1_26 Vdout1_26ck72 = 0 time = 730
.meas tran vdout1_26ck72 FIND v(dout1_26) AT=730.05n

* CHECK dout1_27 Vdout1_27ck72 = 1.8 time = 730
.meas tran vdout1_27ck72 FIND v(dout1_27) AT=730.05n

* CHECK dout1_28 Vdout1_28ck72 = 0 time = 730
.meas tran vdout1_28ck72 FIND v(dout1_28) AT=730.05n

* CHECK dout1_29 Vdout1_29ck72 = 1.8 time = 730
.meas tran vdout1_29ck72 FIND v(dout1_29) AT=730.05n

* CHECK dout1_30 Vdout1_30ck72 = 1.8 time = 730
.meas tran vdout1_30ck72 FIND v(dout1_30) AT=730.05n

* CHECK dout1_31 Vdout1_31ck72 = 0 time = 730
.meas tran vdout1_31ck72 FIND v(dout1_31) AT=730.05n

* CHECK dout1_0 Vdout1_0ck73 = 1.8 time = 740
.meas tran vdout1_0ck73 FIND v(dout1_0) AT=740.05n

* CHECK dout1_1 Vdout1_1ck73 = 1.8 time = 740
.meas tran vdout1_1ck73 FIND v(dout1_1) AT=740.05n

* CHECK dout1_2 Vdout1_2ck73 = 0 time = 740
.meas tran vdout1_2ck73 FIND v(dout1_2) AT=740.05n

* CHECK dout1_3 Vdout1_3ck73 = 1.8 time = 740
.meas tran vdout1_3ck73 FIND v(dout1_3) AT=740.05n

* CHECK dout1_4 Vdout1_4ck73 = 0 time = 740
.meas tran vdout1_4ck73 FIND v(dout1_4) AT=740.05n

* CHECK dout1_5 Vdout1_5ck73 = 0 time = 740
.meas tran vdout1_5ck73 FIND v(dout1_5) AT=740.05n

* CHECK dout1_6 Vdout1_6ck73 = 1.8 time = 740
.meas tran vdout1_6ck73 FIND v(dout1_6) AT=740.05n

* CHECK dout1_7 Vdout1_7ck73 = 0 time = 740
.meas tran vdout1_7ck73 FIND v(dout1_7) AT=740.05n

* CHECK dout1_8 Vdout1_8ck73 = 0 time = 740
.meas tran vdout1_8ck73 FIND v(dout1_8) AT=740.05n

* CHECK dout1_9 Vdout1_9ck73 = 1.8 time = 740
.meas tran vdout1_9ck73 FIND v(dout1_9) AT=740.05n

* CHECK dout1_10 Vdout1_10ck73 = 1.8 time = 740
.meas tran vdout1_10ck73 FIND v(dout1_10) AT=740.05n

* CHECK dout1_11 Vdout1_11ck73 = 1.8 time = 740
.meas tran vdout1_11ck73 FIND v(dout1_11) AT=740.05n

* CHECK dout1_12 Vdout1_12ck73 = 1.8 time = 740
.meas tran vdout1_12ck73 FIND v(dout1_12) AT=740.05n

* CHECK dout1_13 Vdout1_13ck73 = 0 time = 740
.meas tran vdout1_13ck73 FIND v(dout1_13) AT=740.05n

* CHECK dout1_14 Vdout1_14ck73 = 0 time = 740
.meas tran vdout1_14ck73 FIND v(dout1_14) AT=740.05n

* CHECK dout1_15 Vdout1_15ck73 = 0 time = 740
.meas tran vdout1_15ck73 FIND v(dout1_15) AT=740.05n

* CHECK dout1_16 Vdout1_16ck73 = 0 time = 740
.meas tran vdout1_16ck73 FIND v(dout1_16) AT=740.05n

* CHECK dout1_17 Vdout1_17ck73 = 1.8 time = 740
.meas tran vdout1_17ck73 FIND v(dout1_17) AT=740.05n

* CHECK dout1_18 Vdout1_18ck73 = 1.8 time = 740
.meas tran vdout1_18ck73 FIND v(dout1_18) AT=740.05n

* CHECK dout1_19 Vdout1_19ck73 = 0 time = 740
.meas tran vdout1_19ck73 FIND v(dout1_19) AT=740.05n

* CHECK dout1_20 Vdout1_20ck73 = 0 time = 740
.meas tran vdout1_20ck73 FIND v(dout1_20) AT=740.05n

* CHECK dout1_21 Vdout1_21ck73 = 1.8 time = 740
.meas tran vdout1_21ck73 FIND v(dout1_21) AT=740.05n

* CHECK dout1_22 Vdout1_22ck73 = 0 time = 740
.meas tran vdout1_22ck73 FIND v(dout1_22) AT=740.05n

* CHECK dout1_23 Vdout1_23ck73 = 1.8 time = 740
.meas tran vdout1_23ck73 FIND v(dout1_23) AT=740.05n

* CHECK dout1_24 Vdout1_24ck73 = 0 time = 740
.meas tran vdout1_24ck73 FIND v(dout1_24) AT=740.05n

* CHECK dout1_25 Vdout1_25ck73 = 0 time = 740
.meas tran vdout1_25ck73 FIND v(dout1_25) AT=740.05n

* CHECK dout1_26 Vdout1_26ck73 = 0 time = 740
.meas tran vdout1_26ck73 FIND v(dout1_26) AT=740.05n

* CHECK dout1_27 Vdout1_27ck73 = 0 time = 740
.meas tran vdout1_27ck73 FIND v(dout1_27) AT=740.05n

* CHECK dout1_28 Vdout1_28ck73 = 0 time = 740
.meas tran vdout1_28ck73 FIND v(dout1_28) AT=740.05n

* CHECK dout1_29 Vdout1_29ck73 = 0 time = 740
.meas tran vdout1_29ck73 FIND v(dout1_29) AT=740.05n

* CHECK dout1_30 Vdout1_30ck73 = 0 time = 740
.meas tran vdout1_30ck73 FIND v(dout1_30) AT=740.05n

* CHECK dout1_31 Vdout1_31ck73 = 0 time = 740
.meas tran vdout1_31ck73 FIND v(dout1_31) AT=740.05n

* CHECK dout1_0 Vdout1_0ck74 = 0 time = 750
.meas tran vdout1_0ck74 FIND v(dout1_0) AT=750.05n

* CHECK dout1_1 Vdout1_1ck74 = 0 time = 750
.meas tran vdout1_1ck74 FIND v(dout1_1) AT=750.05n

* CHECK dout1_2 Vdout1_2ck74 = 1.8 time = 750
.meas tran vdout1_2ck74 FIND v(dout1_2) AT=750.05n

* CHECK dout1_3 Vdout1_3ck74 = 0 time = 750
.meas tran vdout1_3ck74 FIND v(dout1_3) AT=750.05n

* CHECK dout1_4 Vdout1_4ck74 = 0 time = 750
.meas tran vdout1_4ck74 FIND v(dout1_4) AT=750.05n

* CHECK dout1_5 Vdout1_5ck74 = 1.8 time = 750
.meas tran vdout1_5ck74 FIND v(dout1_5) AT=750.05n

* CHECK dout1_6 Vdout1_6ck74 = 0 time = 750
.meas tran vdout1_6ck74 FIND v(dout1_6) AT=750.05n

* CHECK dout1_7 Vdout1_7ck74 = 1.8 time = 750
.meas tran vdout1_7ck74 FIND v(dout1_7) AT=750.05n

* CHECK dout1_8 Vdout1_8ck74 = 1.8 time = 750
.meas tran vdout1_8ck74 FIND v(dout1_8) AT=750.05n

* CHECK dout1_9 Vdout1_9ck74 = 0 time = 750
.meas tran vdout1_9ck74 FIND v(dout1_9) AT=750.05n

* CHECK dout1_10 Vdout1_10ck74 = 0 time = 750
.meas tran vdout1_10ck74 FIND v(dout1_10) AT=750.05n

* CHECK dout1_11 Vdout1_11ck74 = 1.8 time = 750
.meas tran vdout1_11ck74 FIND v(dout1_11) AT=750.05n

* CHECK dout1_12 Vdout1_12ck74 = 0 time = 750
.meas tran vdout1_12ck74 FIND v(dout1_12) AT=750.05n

* CHECK dout1_13 Vdout1_13ck74 = 1.8 time = 750
.meas tran vdout1_13ck74 FIND v(dout1_13) AT=750.05n

* CHECK dout1_14 Vdout1_14ck74 = 1.8 time = 750
.meas tran vdout1_14ck74 FIND v(dout1_14) AT=750.05n

* CHECK dout1_15 Vdout1_15ck74 = 0 time = 750
.meas tran vdout1_15ck74 FIND v(dout1_15) AT=750.05n

* CHECK dout1_16 Vdout1_16ck74 = 0 time = 750
.meas tran vdout1_16ck74 FIND v(dout1_16) AT=750.05n

* CHECK dout1_17 Vdout1_17ck74 = 0 time = 750
.meas tran vdout1_17ck74 FIND v(dout1_17) AT=750.05n

* CHECK dout1_18 Vdout1_18ck74 = 1.8 time = 750
.meas tran vdout1_18ck74 FIND v(dout1_18) AT=750.05n

* CHECK dout1_19 Vdout1_19ck74 = 0 time = 750
.meas tran vdout1_19ck74 FIND v(dout1_19) AT=750.05n

* CHECK dout1_20 Vdout1_20ck74 = 0 time = 750
.meas tran vdout1_20ck74 FIND v(dout1_20) AT=750.05n

* CHECK dout1_21 Vdout1_21ck74 = 1.8 time = 750
.meas tran vdout1_21ck74 FIND v(dout1_21) AT=750.05n

* CHECK dout1_22 Vdout1_22ck74 = 0 time = 750
.meas tran vdout1_22ck74 FIND v(dout1_22) AT=750.05n

* CHECK dout1_23 Vdout1_23ck74 = 0 time = 750
.meas tran vdout1_23ck74 FIND v(dout1_23) AT=750.05n

* CHECK dout1_24 Vdout1_24ck74 = 0 time = 750
.meas tran vdout1_24ck74 FIND v(dout1_24) AT=750.05n

* CHECK dout1_25 Vdout1_25ck74 = 0 time = 750
.meas tran vdout1_25ck74 FIND v(dout1_25) AT=750.05n

* CHECK dout1_26 Vdout1_26ck74 = 0 time = 750
.meas tran vdout1_26ck74 FIND v(dout1_26) AT=750.05n

* CHECK dout1_27 Vdout1_27ck74 = 1.8 time = 750
.meas tran vdout1_27ck74 FIND v(dout1_27) AT=750.05n

* CHECK dout1_28 Vdout1_28ck74 = 1.8 time = 750
.meas tran vdout1_28ck74 FIND v(dout1_28) AT=750.05n

* CHECK dout1_29 Vdout1_29ck74 = 0 time = 750
.meas tran vdout1_29ck74 FIND v(dout1_29) AT=750.05n

* CHECK dout1_30 Vdout1_30ck74 = 0 time = 750
.meas tran vdout1_30ck74 FIND v(dout1_30) AT=750.05n

* CHECK dout1_31 Vdout1_31ck74 = 1.8 time = 750
.meas tran vdout1_31ck74 FIND v(dout1_31) AT=750.05n

* CHECK dout1_0 Vdout1_0ck75 = 1.8 time = 760
.meas tran vdout1_0ck75 FIND v(dout1_0) AT=760.05n

* CHECK dout1_1 Vdout1_1ck75 = 1.8 time = 760
.meas tran vdout1_1ck75 FIND v(dout1_1) AT=760.05n

* CHECK dout1_2 Vdout1_2ck75 = 1.8 time = 760
.meas tran vdout1_2ck75 FIND v(dout1_2) AT=760.05n

* CHECK dout1_3 Vdout1_3ck75 = 0 time = 760
.meas tran vdout1_3ck75 FIND v(dout1_3) AT=760.05n

* CHECK dout1_4 Vdout1_4ck75 = 1.8 time = 760
.meas tran vdout1_4ck75 FIND v(dout1_4) AT=760.05n

* CHECK dout1_5 Vdout1_5ck75 = 1.8 time = 760
.meas tran vdout1_5ck75 FIND v(dout1_5) AT=760.05n

* CHECK dout1_6 Vdout1_6ck75 = 1.8 time = 760
.meas tran vdout1_6ck75 FIND v(dout1_6) AT=760.05n

* CHECK dout1_7 Vdout1_7ck75 = 1.8 time = 760
.meas tran vdout1_7ck75 FIND v(dout1_7) AT=760.05n

* CHECK dout1_8 Vdout1_8ck75 = 0 time = 760
.meas tran vdout1_8ck75 FIND v(dout1_8) AT=760.05n

* CHECK dout1_9 Vdout1_9ck75 = 0 time = 760
.meas tran vdout1_9ck75 FIND v(dout1_9) AT=760.05n

* CHECK dout1_10 Vdout1_10ck75 = 1.8 time = 760
.meas tran vdout1_10ck75 FIND v(dout1_10) AT=760.05n

* CHECK dout1_11 Vdout1_11ck75 = 0 time = 760
.meas tran vdout1_11ck75 FIND v(dout1_11) AT=760.05n

* CHECK dout1_12 Vdout1_12ck75 = 1.8 time = 760
.meas tran vdout1_12ck75 FIND v(dout1_12) AT=760.05n

* CHECK dout1_13 Vdout1_13ck75 = 0 time = 760
.meas tran vdout1_13ck75 FIND v(dout1_13) AT=760.05n

* CHECK dout1_14 Vdout1_14ck75 = 1.8 time = 760
.meas tran vdout1_14ck75 FIND v(dout1_14) AT=760.05n

* CHECK dout1_15 Vdout1_15ck75 = 1.8 time = 760
.meas tran vdout1_15ck75 FIND v(dout1_15) AT=760.05n

* CHECK dout1_16 Vdout1_16ck75 = 1.8 time = 760
.meas tran vdout1_16ck75 FIND v(dout1_16) AT=760.05n

* CHECK dout1_17 Vdout1_17ck75 = 0 time = 760
.meas tran vdout1_17ck75 FIND v(dout1_17) AT=760.05n

* CHECK dout1_18 Vdout1_18ck75 = 1.8 time = 760
.meas tran vdout1_18ck75 FIND v(dout1_18) AT=760.05n

* CHECK dout1_19 Vdout1_19ck75 = 0 time = 760
.meas tran vdout1_19ck75 FIND v(dout1_19) AT=760.05n

* CHECK dout1_20 Vdout1_20ck75 = 1.8 time = 760
.meas tran vdout1_20ck75 FIND v(dout1_20) AT=760.05n

* CHECK dout1_21 Vdout1_21ck75 = 1.8 time = 760
.meas tran vdout1_21ck75 FIND v(dout1_21) AT=760.05n

* CHECK dout1_22 Vdout1_22ck75 = 1.8 time = 760
.meas tran vdout1_22ck75 FIND v(dout1_22) AT=760.05n

* CHECK dout1_23 Vdout1_23ck75 = 0 time = 760
.meas tran vdout1_23ck75 FIND v(dout1_23) AT=760.05n

* CHECK dout1_24 Vdout1_24ck75 = 0 time = 760
.meas tran vdout1_24ck75 FIND v(dout1_24) AT=760.05n

* CHECK dout1_25 Vdout1_25ck75 = 1.8 time = 760
.meas tran vdout1_25ck75 FIND v(dout1_25) AT=760.05n

* CHECK dout1_26 Vdout1_26ck75 = 0 time = 760
.meas tran vdout1_26ck75 FIND v(dout1_26) AT=760.05n

* CHECK dout1_27 Vdout1_27ck75 = 1.8 time = 760
.meas tran vdout1_27ck75 FIND v(dout1_27) AT=760.05n

* CHECK dout1_28 Vdout1_28ck75 = 0 time = 760
.meas tran vdout1_28ck75 FIND v(dout1_28) AT=760.05n

* CHECK dout1_29 Vdout1_29ck75 = 1.8 time = 760
.meas tran vdout1_29ck75 FIND v(dout1_29) AT=760.05n

* CHECK dout1_30 Vdout1_30ck75 = 1.8 time = 760
.meas tran vdout1_30ck75 FIND v(dout1_30) AT=760.05n

* CHECK dout1_31 Vdout1_31ck75 = 0 time = 760
.meas tran vdout1_31ck75 FIND v(dout1_31) AT=760.05n

* CHECK dout1_0 Vdout1_0ck78 = 0 time = 790
.meas tran vdout1_0ck78 FIND v(dout1_0) AT=790.05n

* CHECK dout1_1 Vdout1_1ck78 = 0 time = 790
.meas tran vdout1_1ck78 FIND v(dout1_1) AT=790.05n

* CHECK dout1_2 Vdout1_2ck78 = 1.8 time = 790
.meas tran vdout1_2ck78 FIND v(dout1_2) AT=790.05n

* CHECK dout1_3 Vdout1_3ck78 = 0 time = 790
.meas tran vdout1_3ck78 FIND v(dout1_3) AT=790.05n

* CHECK dout1_4 Vdout1_4ck78 = 0 time = 790
.meas tran vdout1_4ck78 FIND v(dout1_4) AT=790.05n

* CHECK dout1_5 Vdout1_5ck78 = 1.8 time = 790
.meas tran vdout1_5ck78 FIND v(dout1_5) AT=790.05n

* CHECK dout1_6 Vdout1_6ck78 = 0 time = 790
.meas tran vdout1_6ck78 FIND v(dout1_6) AT=790.05n

* CHECK dout1_7 Vdout1_7ck78 = 1.8 time = 790
.meas tran vdout1_7ck78 FIND v(dout1_7) AT=790.05n

* CHECK dout1_8 Vdout1_8ck78 = 1.8 time = 790
.meas tran vdout1_8ck78 FIND v(dout1_8) AT=790.05n

* CHECK dout1_9 Vdout1_9ck78 = 0 time = 790
.meas tran vdout1_9ck78 FIND v(dout1_9) AT=790.05n

* CHECK dout1_10 Vdout1_10ck78 = 0 time = 790
.meas tran vdout1_10ck78 FIND v(dout1_10) AT=790.05n

* CHECK dout1_11 Vdout1_11ck78 = 1.8 time = 790
.meas tran vdout1_11ck78 FIND v(dout1_11) AT=790.05n

* CHECK dout1_12 Vdout1_12ck78 = 0 time = 790
.meas tran vdout1_12ck78 FIND v(dout1_12) AT=790.05n

* CHECK dout1_13 Vdout1_13ck78 = 1.8 time = 790
.meas tran vdout1_13ck78 FIND v(dout1_13) AT=790.05n

* CHECK dout1_14 Vdout1_14ck78 = 1.8 time = 790
.meas tran vdout1_14ck78 FIND v(dout1_14) AT=790.05n

* CHECK dout1_15 Vdout1_15ck78 = 0 time = 790
.meas tran vdout1_15ck78 FIND v(dout1_15) AT=790.05n

* CHECK dout1_16 Vdout1_16ck78 = 0 time = 790
.meas tran vdout1_16ck78 FIND v(dout1_16) AT=790.05n

* CHECK dout1_17 Vdout1_17ck78 = 0 time = 790
.meas tran vdout1_17ck78 FIND v(dout1_17) AT=790.05n

* CHECK dout1_18 Vdout1_18ck78 = 1.8 time = 790
.meas tran vdout1_18ck78 FIND v(dout1_18) AT=790.05n

* CHECK dout1_19 Vdout1_19ck78 = 0 time = 790
.meas tran vdout1_19ck78 FIND v(dout1_19) AT=790.05n

* CHECK dout1_20 Vdout1_20ck78 = 0 time = 790
.meas tran vdout1_20ck78 FIND v(dout1_20) AT=790.05n

* CHECK dout1_21 Vdout1_21ck78 = 1.8 time = 790
.meas tran vdout1_21ck78 FIND v(dout1_21) AT=790.05n

* CHECK dout1_22 Vdout1_22ck78 = 0 time = 790
.meas tran vdout1_22ck78 FIND v(dout1_22) AT=790.05n

* CHECK dout1_23 Vdout1_23ck78 = 0 time = 790
.meas tran vdout1_23ck78 FIND v(dout1_23) AT=790.05n

* CHECK dout1_24 Vdout1_24ck78 = 0 time = 790
.meas tran vdout1_24ck78 FIND v(dout1_24) AT=790.05n

* CHECK dout1_25 Vdout1_25ck78 = 0 time = 790
.meas tran vdout1_25ck78 FIND v(dout1_25) AT=790.05n

* CHECK dout1_26 Vdout1_26ck78 = 0 time = 790
.meas tran vdout1_26ck78 FIND v(dout1_26) AT=790.05n

* CHECK dout1_27 Vdout1_27ck78 = 1.8 time = 790
.meas tran vdout1_27ck78 FIND v(dout1_27) AT=790.05n

* CHECK dout1_28 Vdout1_28ck78 = 1.8 time = 790
.meas tran vdout1_28ck78 FIND v(dout1_28) AT=790.05n

* CHECK dout1_29 Vdout1_29ck78 = 0 time = 790
.meas tran vdout1_29ck78 FIND v(dout1_29) AT=790.05n

* CHECK dout1_30 Vdout1_30ck78 = 0 time = 790
.meas tran vdout1_30ck78 FIND v(dout1_30) AT=790.05n

* CHECK dout1_31 Vdout1_31ck78 = 1.8 time = 790
.meas tran vdout1_31ck78 FIND v(dout1_31) AT=790.05n

* CHECK dout1_0 Vdout1_0ck81 = 1.8 time = 820
.meas tran vdout1_0ck81 FIND v(dout1_0) AT=820.05n

* CHECK dout1_1 Vdout1_1ck81 = 1.8 time = 820
.meas tran vdout1_1ck81 FIND v(dout1_1) AT=820.05n

* CHECK dout1_2 Vdout1_2ck81 = 1.8 time = 820
.meas tran vdout1_2ck81 FIND v(dout1_2) AT=820.05n

* CHECK dout1_3 Vdout1_3ck81 = 1.8 time = 820
.meas tran vdout1_3ck81 FIND v(dout1_3) AT=820.05n

* CHECK dout1_4 Vdout1_4ck81 = 1.8 time = 820
.meas tran vdout1_4ck81 FIND v(dout1_4) AT=820.05n

* CHECK dout1_5 Vdout1_5ck81 = 1.8 time = 820
.meas tran vdout1_5ck81 FIND v(dout1_5) AT=820.05n

* CHECK dout1_6 Vdout1_6ck81 = 0 time = 820
.meas tran vdout1_6ck81 FIND v(dout1_6) AT=820.05n

* CHECK dout1_7 Vdout1_7ck81 = 0 time = 820
.meas tran vdout1_7ck81 FIND v(dout1_7) AT=820.05n

* CHECK dout1_8 Vdout1_8ck81 = 1.8 time = 820
.meas tran vdout1_8ck81 FIND v(dout1_8) AT=820.05n

* CHECK dout1_9 Vdout1_9ck81 = 1.8 time = 820
.meas tran vdout1_9ck81 FIND v(dout1_9) AT=820.05n

* CHECK dout1_10 Vdout1_10ck81 = 1.8 time = 820
.meas tran vdout1_10ck81 FIND v(dout1_10) AT=820.05n

* CHECK dout1_11 Vdout1_11ck81 = 0 time = 820
.meas tran vdout1_11ck81 FIND v(dout1_11) AT=820.05n

* CHECK dout1_12 Vdout1_12ck81 = 1.8 time = 820
.meas tran vdout1_12ck81 FIND v(dout1_12) AT=820.05n

* CHECK dout1_13 Vdout1_13ck81 = 1.8 time = 820
.meas tran vdout1_13ck81 FIND v(dout1_13) AT=820.05n

* CHECK dout1_14 Vdout1_14ck81 = 0 time = 820
.meas tran vdout1_14ck81 FIND v(dout1_14) AT=820.05n

* CHECK dout1_15 Vdout1_15ck81 = 0 time = 820
.meas tran vdout1_15ck81 FIND v(dout1_15) AT=820.05n

* CHECK dout1_16 Vdout1_16ck81 = 0 time = 820
.meas tran vdout1_16ck81 FIND v(dout1_16) AT=820.05n

* CHECK dout1_17 Vdout1_17ck81 = 0 time = 820
.meas tran vdout1_17ck81 FIND v(dout1_17) AT=820.05n

* CHECK dout1_18 Vdout1_18ck81 = 0 time = 820
.meas tran vdout1_18ck81 FIND v(dout1_18) AT=820.05n

* CHECK dout1_19 Vdout1_19ck81 = 0 time = 820
.meas tran vdout1_19ck81 FIND v(dout1_19) AT=820.05n

* CHECK dout1_20 Vdout1_20ck81 = 1.8 time = 820
.meas tran vdout1_20ck81 FIND v(dout1_20) AT=820.05n

* CHECK dout1_21 Vdout1_21ck81 = 0 time = 820
.meas tran vdout1_21ck81 FIND v(dout1_21) AT=820.05n

* CHECK dout1_22 Vdout1_22ck81 = 1.8 time = 820
.meas tran vdout1_22ck81 FIND v(dout1_22) AT=820.05n

* CHECK dout1_23 Vdout1_23ck81 = 0 time = 820
.meas tran vdout1_23ck81 FIND v(dout1_23) AT=820.05n

* CHECK dout1_24 Vdout1_24ck81 = 1.8 time = 820
.meas tran vdout1_24ck81 FIND v(dout1_24) AT=820.05n

* CHECK dout1_25 Vdout1_25ck81 = 0 time = 820
.meas tran vdout1_25ck81 FIND v(dout1_25) AT=820.05n

* CHECK dout1_26 Vdout1_26ck81 = 1.8 time = 820
.meas tran vdout1_26ck81 FIND v(dout1_26) AT=820.05n

* CHECK dout1_27 Vdout1_27ck81 = 1.8 time = 820
.meas tran vdout1_27ck81 FIND v(dout1_27) AT=820.05n

* CHECK dout1_28 Vdout1_28ck81 = 0 time = 820
.meas tran vdout1_28ck81 FIND v(dout1_28) AT=820.05n

* CHECK dout1_29 Vdout1_29ck81 = 1.8 time = 820
.meas tran vdout1_29ck81 FIND v(dout1_29) AT=820.05n

* CHECK dout1_30 Vdout1_30ck81 = 1.8 time = 820
.meas tran vdout1_30ck81 FIND v(dout1_30) AT=820.05n

* CHECK dout1_31 Vdout1_31ck81 = 0 time = 820
.meas tran vdout1_31ck81 FIND v(dout1_31) AT=820.05n

* CHECK dout0_0 Vdout0_0ck83 = 0 time = 840
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=840.05n

* CHECK dout0_1 Vdout0_1ck83 = 1.8 time = 840
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=840.05n

* CHECK dout0_2 Vdout0_2ck83 = 0 time = 840
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=840.05n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 840
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=840.05n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 840
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=840.05n

* CHECK dout0_5 Vdout0_5ck83 = 1.8 time = 840
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=840.05n

* CHECK dout0_6 Vdout0_6ck83 = 1.8 time = 840
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=840.05n

* CHECK dout0_7 Vdout0_7ck83 = 1.8 time = 840
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=840.05n

* CHECK dout0_8 Vdout0_8ck83 = 1.8 time = 840
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=840.05n

* CHECK dout0_9 Vdout0_9ck83 = 0 time = 840
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=840.05n

* CHECK dout0_10 Vdout0_10ck83 = 1.8 time = 840
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=840.05n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 840
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=840.05n

* CHECK dout0_12 Vdout0_12ck83 = 1.8 time = 840
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=840.05n

* CHECK dout0_13 Vdout0_13ck83 = 1.8 time = 840
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=840.05n

* CHECK dout0_14 Vdout0_14ck83 = 0 time = 840
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=840.05n

* CHECK dout0_15 Vdout0_15ck83 = 1.8 time = 840
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=840.05n

* CHECK dout0_16 Vdout0_16ck83 = 1.8 time = 840
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=840.05n

* CHECK dout0_17 Vdout0_17ck83 = 1.8 time = 840
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=840.05n

* CHECK dout0_18 Vdout0_18ck83 = 0 time = 840
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=840.05n

* CHECK dout0_19 Vdout0_19ck83 = 1.8 time = 840
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=840.05n

* CHECK dout0_20 Vdout0_20ck83 = 1.8 time = 840
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=840.05n

* CHECK dout0_21 Vdout0_21ck83 = 1.8 time = 840
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=840.05n

* CHECK dout0_22 Vdout0_22ck83 = 0 time = 840
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=840.05n

* CHECK dout0_23 Vdout0_23ck83 = 1.8 time = 840
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=840.05n

* CHECK dout0_24 Vdout0_24ck83 = 0 time = 840
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=840.05n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 840
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=840.05n

* CHECK dout0_26 Vdout0_26ck83 = 1.8 time = 840
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=840.05n

* CHECK dout0_27 Vdout0_27ck83 = 0 time = 840
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=840.05n

* CHECK dout0_28 Vdout0_28ck83 = 1.8 time = 840
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=840.05n

* CHECK dout0_29 Vdout0_29ck83 = 1.8 time = 840
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=840.05n

* CHECK dout0_30 Vdout0_30ck83 = 0 time = 840
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=840.05n

* CHECK dout0_31 Vdout0_31ck83 = 1.8 time = 840
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=840.05n

* CHECK dout1_0 Vdout1_0ck83 = 0 time = 840
.meas tran vdout1_0ck83 FIND v(dout1_0) AT=840.05n

* CHECK dout1_1 Vdout1_1ck83 = 0 time = 840
.meas tran vdout1_1ck83 FIND v(dout1_1) AT=840.05n

* CHECK dout1_2 Vdout1_2ck83 = 0 time = 840
.meas tran vdout1_2ck83 FIND v(dout1_2) AT=840.05n

* CHECK dout1_3 Vdout1_3ck83 = 1.8 time = 840
.meas tran vdout1_3ck83 FIND v(dout1_3) AT=840.05n

* CHECK dout1_4 Vdout1_4ck83 = 0 time = 840
.meas tran vdout1_4ck83 FIND v(dout1_4) AT=840.05n

* CHECK dout1_5 Vdout1_5ck83 = 0 time = 840
.meas tran vdout1_5ck83 FIND v(dout1_5) AT=840.05n

* CHECK dout1_6 Vdout1_6ck83 = 1.8 time = 840
.meas tran vdout1_6ck83 FIND v(dout1_6) AT=840.05n

* CHECK dout1_7 Vdout1_7ck83 = 1.8 time = 840
.meas tran vdout1_7ck83 FIND v(dout1_7) AT=840.05n

* CHECK dout1_8 Vdout1_8ck83 = 0 time = 840
.meas tran vdout1_8ck83 FIND v(dout1_8) AT=840.05n

* CHECK dout1_9 Vdout1_9ck83 = 1.8 time = 840
.meas tran vdout1_9ck83 FIND v(dout1_9) AT=840.05n

* CHECK dout1_10 Vdout1_10ck83 = 0 time = 840
.meas tran vdout1_10ck83 FIND v(dout1_10) AT=840.05n

* CHECK dout1_11 Vdout1_11ck83 = 1.8 time = 840
.meas tran vdout1_11ck83 FIND v(dout1_11) AT=840.05n

* CHECK dout1_12 Vdout1_12ck83 = 1.8 time = 840
.meas tran vdout1_12ck83 FIND v(dout1_12) AT=840.05n

* CHECK dout1_13 Vdout1_13ck83 = 1.8 time = 840
.meas tran vdout1_13ck83 FIND v(dout1_13) AT=840.05n

* CHECK dout1_14 Vdout1_14ck83 = 1.8 time = 840
.meas tran vdout1_14ck83 FIND v(dout1_14) AT=840.05n

* CHECK dout1_15 Vdout1_15ck83 = 0 time = 840
.meas tran vdout1_15ck83 FIND v(dout1_15) AT=840.05n

* CHECK dout1_16 Vdout1_16ck83 = 1.8 time = 840
.meas tran vdout1_16ck83 FIND v(dout1_16) AT=840.05n

* CHECK dout1_17 Vdout1_17ck83 = 0 time = 840
.meas tran vdout1_17ck83 FIND v(dout1_17) AT=840.05n

* CHECK dout1_18 Vdout1_18ck83 = 0 time = 840
.meas tran vdout1_18ck83 FIND v(dout1_18) AT=840.05n

* CHECK dout1_19 Vdout1_19ck83 = 1.8 time = 840
.meas tran vdout1_19ck83 FIND v(dout1_19) AT=840.05n

* CHECK dout1_20 Vdout1_20ck83 = 0 time = 840
.meas tran vdout1_20ck83 FIND v(dout1_20) AT=840.05n

* CHECK dout1_21 Vdout1_21ck83 = 0 time = 840
.meas tran vdout1_21ck83 FIND v(dout1_21) AT=840.05n

* CHECK dout1_22 Vdout1_22ck83 = 0 time = 840
.meas tran vdout1_22ck83 FIND v(dout1_22) AT=840.05n

* CHECK dout1_23 Vdout1_23ck83 = 1.8 time = 840
.meas tran vdout1_23ck83 FIND v(dout1_23) AT=840.05n

* CHECK dout1_24 Vdout1_24ck83 = 1.8 time = 840
.meas tran vdout1_24ck83 FIND v(dout1_24) AT=840.05n

* CHECK dout1_25 Vdout1_25ck83 = 1.8 time = 840
.meas tran vdout1_25ck83 FIND v(dout1_25) AT=840.05n

* CHECK dout1_26 Vdout1_26ck83 = 0 time = 840
.meas tran vdout1_26ck83 FIND v(dout1_26) AT=840.05n

* CHECK dout1_27 Vdout1_27ck83 = 1.8 time = 840
.meas tran vdout1_27ck83 FIND v(dout1_27) AT=840.05n

* CHECK dout1_28 Vdout1_28ck83 = 0 time = 840
.meas tran vdout1_28ck83 FIND v(dout1_28) AT=840.05n

* CHECK dout1_29 Vdout1_29ck83 = 0 time = 840
.meas tran vdout1_29ck83 FIND v(dout1_29) AT=840.05n

* CHECK dout1_30 Vdout1_30ck83 = 0 time = 840
.meas tran vdout1_30ck83 FIND v(dout1_30) AT=840.05n

* CHECK dout1_31 Vdout1_31ck83 = 1.8 time = 840
.meas tran vdout1_31ck83 FIND v(dout1_31) AT=840.05n

* CHECK dout1_0 Vdout1_0ck84 = 0 time = 850
.meas tran vdout1_0ck84 FIND v(dout1_0) AT=850.05n

* CHECK dout1_1 Vdout1_1ck84 = 1.8 time = 850
.meas tran vdout1_1ck84 FIND v(dout1_1) AT=850.05n

* CHECK dout1_2 Vdout1_2ck84 = 0 time = 850
.meas tran vdout1_2ck84 FIND v(dout1_2) AT=850.05n

* CHECK dout1_3 Vdout1_3ck84 = 0 time = 850
.meas tran vdout1_3ck84 FIND v(dout1_3) AT=850.05n

* CHECK dout1_4 Vdout1_4ck84 = 0 time = 850
.meas tran vdout1_4ck84 FIND v(dout1_4) AT=850.05n

* CHECK dout1_5 Vdout1_5ck84 = 1.8 time = 850
.meas tran vdout1_5ck84 FIND v(dout1_5) AT=850.05n

* CHECK dout1_6 Vdout1_6ck84 = 1.8 time = 850
.meas tran vdout1_6ck84 FIND v(dout1_6) AT=850.05n

* CHECK dout1_7 Vdout1_7ck84 = 1.8 time = 850
.meas tran vdout1_7ck84 FIND v(dout1_7) AT=850.05n

* CHECK dout1_8 Vdout1_8ck84 = 1.8 time = 850
.meas tran vdout1_8ck84 FIND v(dout1_8) AT=850.05n

* CHECK dout1_9 Vdout1_9ck84 = 0 time = 850
.meas tran vdout1_9ck84 FIND v(dout1_9) AT=850.05n

* CHECK dout1_10 Vdout1_10ck84 = 1.8 time = 850
.meas tran vdout1_10ck84 FIND v(dout1_10) AT=850.05n

* CHECK dout1_11 Vdout1_11ck84 = 1.8 time = 850
.meas tran vdout1_11ck84 FIND v(dout1_11) AT=850.05n

* CHECK dout1_12 Vdout1_12ck84 = 1.8 time = 850
.meas tran vdout1_12ck84 FIND v(dout1_12) AT=850.05n

* CHECK dout1_13 Vdout1_13ck84 = 1.8 time = 850
.meas tran vdout1_13ck84 FIND v(dout1_13) AT=850.05n

* CHECK dout1_14 Vdout1_14ck84 = 0 time = 850
.meas tran vdout1_14ck84 FIND v(dout1_14) AT=850.05n

* CHECK dout1_15 Vdout1_15ck84 = 1.8 time = 850
.meas tran vdout1_15ck84 FIND v(dout1_15) AT=850.05n

* CHECK dout1_16 Vdout1_16ck84 = 1.8 time = 850
.meas tran vdout1_16ck84 FIND v(dout1_16) AT=850.05n

* CHECK dout1_17 Vdout1_17ck84 = 1.8 time = 850
.meas tran vdout1_17ck84 FIND v(dout1_17) AT=850.05n

* CHECK dout1_18 Vdout1_18ck84 = 0 time = 850
.meas tran vdout1_18ck84 FIND v(dout1_18) AT=850.05n

* CHECK dout1_19 Vdout1_19ck84 = 1.8 time = 850
.meas tran vdout1_19ck84 FIND v(dout1_19) AT=850.05n

* CHECK dout1_20 Vdout1_20ck84 = 1.8 time = 850
.meas tran vdout1_20ck84 FIND v(dout1_20) AT=850.05n

* CHECK dout1_21 Vdout1_21ck84 = 1.8 time = 850
.meas tran vdout1_21ck84 FIND v(dout1_21) AT=850.05n

* CHECK dout1_22 Vdout1_22ck84 = 0 time = 850
.meas tran vdout1_22ck84 FIND v(dout1_22) AT=850.05n

* CHECK dout1_23 Vdout1_23ck84 = 1.8 time = 850
.meas tran vdout1_23ck84 FIND v(dout1_23) AT=850.05n

* CHECK dout1_24 Vdout1_24ck84 = 0 time = 850
.meas tran vdout1_24ck84 FIND v(dout1_24) AT=850.05n

* CHECK dout1_25 Vdout1_25ck84 = 0 time = 850
.meas tran vdout1_25ck84 FIND v(dout1_25) AT=850.05n

* CHECK dout1_26 Vdout1_26ck84 = 1.8 time = 850
.meas tran vdout1_26ck84 FIND v(dout1_26) AT=850.05n

* CHECK dout1_27 Vdout1_27ck84 = 0 time = 850
.meas tran vdout1_27ck84 FIND v(dout1_27) AT=850.05n

* CHECK dout1_28 Vdout1_28ck84 = 1.8 time = 850
.meas tran vdout1_28ck84 FIND v(dout1_28) AT=850.05n

* CHECK dout1_29 Vdout1_29ck84 = 1.8 time = 850
.meas tran vdout1_29ck84 FIND v(dout1_29) AT=850.05n

* CHECK dout1_30 Vdout1_30ck84 = 0 time = 850
.meas tran vdout1_30ck84 FIND v(dout1_30) AT=850.05n

* CHECK dout1_31 Vdout1_31ck84 = 1.8 time = 850
.meas tran vdout1_31ck84 FIND v(dout1_31) AT=850.05n

* CHECK dout1_0 Vdout1_0ck86 = 1.8 time = 870
.meas tran vdout1_0ck86 FIND v(dout1_0) AT=870.05n

* CHECK dout1_1 Vdout1_1ck86 = 1.8 time = 870
.meas tran vdout1_1ck86 FIND v(dout1_1) AT=870.05n

* CHECK dout1_2 Vdout1_2ck86 = 1.8 time = 870
.meas tran vdout1_2ck86 FIND v(dout1_2) AT=870.05n

* CHECK dout1_3 Vdout1_3ck86 = 0 time = 870
.meas tran vdout1_3ck86 FIND v(dout1_3) AT=870.05n

* CHECK dout1_4 Vdout1_4ck86 = 0 time = 870
.meas tran vdout1_4ck86 FIND v(dout1_4) AT=870.05n

* CHECK dout1_5 Vdout1_5ck86 = 0 time = 870
.meas tran vdout1_5ck86 FIND v(dout1_5) AT=870.05n

* CHECK dout1_6 Vdout1_6ck86 = 0 time = 870
.meas tran vdout1_6ck86 FIND v(dout1_6) AT=870.05n

* CHECK dout1_7 Vdout1_7ck86 = 1.8 time = 870
.meas tran vdout1_7ck86 FIND v(dout1_7) AT=870.05n

* CHECK dout1_8 Vdout1_8ck86 = 0 time = 870
.meas tran vdout1_8ck86 FIND v(dout1_8) AT=870.05n

* CHECK dout1_9 Vdout1_9ck86 = 0 time = 870
.meas tran vdout1_9ck86 FIND v(dout1_9) AT=870.05n

* CHECK dout1_10 Vdout1_10ck86 = 0 time = 870
.meas tran vdout1_10ck86 FIND v(dout1_10) AT=870.05n

* CHECK dout1_11 Vdout1_11ck86 = 1.8 time = 870
.meas tran vdout1_11ck86 FIND v(dout1_11) AT=870.05n

* CHECK dout1_12 Vdout1_12ck86 = 0 time = 870
.meas tran vdout1_12ck86 FIND v(dout1_12) AT=870.05n

* CHECK dout1_13 Vdout1_13ck86 = 0 time = 870
.meas tran vdout1_13ck86 FIND v(dout1_13) AT=870.05n

* CHECK dout1_14 Vdout1_14ck86 = 0 time = 870
.meas tran vdout1_14ck86 FIND v(dout1_14) AT=870.05n

* CHECK dout1_15 Vdout1_15ck86 = 1.8 time = 870
.meas tran vdout1_15ck86 FIND v(dout1_15) AT=870.05n

* CHECK dout1_16 Vdout1_16ck86 = 1.8 time = 870
.meas tran vdout1_16ck86 FIND v(dout1_16) AT=870.05n

* CHECK dout1_17 Vdout1_17ck86 = 0 time = 870
.meas tran vdout1_17ck86 FIND v(dout1_17) AT=870.05n

* CHECK dout1_18 Vdout1_18ck86 = 1.8 time = 870
.meas tran vdout1_18ck86 FIND v(dout1_18) AT=870.05n

* CHECK dout1_19 Vdout1_19ck86 = 1.8 time = 870
.meas tran vdout1_19ck86 FIND v(dout1_19) AT=870.05n

* CHECK dout1_20 Vdout1_20ck86 = 0 time = 870
.meas tran vdout1_20ck86 FIND v(dout1_20) AT=870.05n

* CHECK dout1_21 Vdout1_21ck86 = 1.8 time = 870
.meas tran vdout1_21ck86 FIND v(dout1_21) AT=870.05n

* CHECK dout1_22 Vdout1_22ck86 = 0 time = 870
.meas tran vdout1_22ck86 FIND v(dout1_22) AT=870.05n

* CHECK dout1_23 Vdout1_23ck86 = 0 time = 870
.meas tran vdout1_23ck86 FIND v(dout1_23) AT=870.05n

* CHECK dout1_24 Vdout1_24ck86 = 1.8 time = 870
.meas tran vdout1_24ck86 FIND v(dout1_24) AT=870.05n

* CHECK dout1_25 Vdout1_25ck86 = 0 time = 870
.meas tran vdout1_25ck86 FIND v(dout1_25) AT=870.05n

* CHECK dout1_26 Vdout1_26ck86 = 1.8 time = 870
.meas tran vdout1_26ck86 FIND v(dout1_26) AT=870.05n

* CHECK dout1_27 Vdout1_27ck86 = 1.8 time = 870
.meas tran vdout1_27ck86 FIND v(dout1_27) AT=870.05n

* CHECK dout1_28 Vdout1_28ck86 = 1.8 time = 870
.meas tran vdout1_28ck86 FIND v(dout1_28) AT=870.05n

* CHECK dout1_29 Vdout1_29ck86 = 0 time = 870
.meas tran vdout1_29ck86 FIND v(dout1_29) AT=870.05n

* CHECK dout1_30 Vdout1_30ck86 = 0 time = 870
.meas tran vdout1_30ck86 FIND v(dout1_30) AT=870.05n

* CHECK dout1_31 Vdout1_31ck86 = 0 time = 870
.meas tran vdout1_31ck86 FIND v(dout1_31) AT=870.05n

* CHECK dout0_0 Vdout0_0ck87 = 0 time = 880
.meas tran vdout0_0ck87 FIND v(dout0_0) AT=880.05n

* CHECK dout0_1 Vdout0_1ck87 = 1.8 time = 880
.meas tran vdout0_1ck87 FIND v(dout0_1) AT=880.05n

* CHECK dout0_2 Vdout0_2ck87 = 0 time = 880
.meas tran vdout0_2ck87 FIND v(dout0_2) AT=880.05n

* CHECK dout0_3 Vdout0_3ck87 = 0 time = 880
.meas tran vdout0_3ck87 FIND v(dout0_3) AT=880.05n

* CHECK dout0_4 Vdout0_4ck87 = 0 time = 880
.meas tran vdout0_4ck87 FIND v(dout0_4) AT=880.05n

* CHECK dout0_5 Vdout0_5ck87 = 1.8 time = 880
.meas tran vdout0_5ck87 FIND v(dout0_5) AT=880.05n

* CHECK dout0_6 Vdout0_6ck87 = 1.8 time = 880
.meas tran vdout0_6ck87 FIND v(dout0_6) AT=880.05n

* CHECK dout0_7 Vdout0_7ck87 = 1.8 time = 880
.meas tran vdout0_7ck87 FIND v(dout0_7) AT=880.05n

* CHECK dout0_8 Vdout0_8ck87 = 1.8 time = 880
.meas tran vdout0_8ck87 FIND v(dout0_8) AT=880.05n

* CHECK dout0_9 Vdout0_9ck87 = 0 time = 880
.meas tran vdout0_9ck87 FIND v(dout0_9) AT=880.05n

* CHECK dout0_10 Vdout0_10ck87 = 1.8 time = 880
.meas tran vdout0_10ck87 FIND v(dout0_10) AT=880.05n

* CHECK dout0_11 Vdout0_11ck87 = 1.8 time = 880
.meas tran vdout0_11ck87 FIND v(dout0_11) AT=880.05n

* CHECK dout0_12 Vdout0_12ck87 = 1.8 time = 880
.meas tran vdout0_12ck87 FIND v(dout0_12) AT=880.05n

* CHECK dout0_13 Vdout0_13ck87 = 1.8 time = 880
.meas tran vdout0_13ck87 FIND v(dout0_13) AT=880.05n

* CHECK dout0_14 Vdout0_14ck87 = 0 time = 880
.meas tran vdout0_14ck87 FIND v(dout0_14) AT=880.05n

* CHECK dout0_15 Vdout0_15ck87 = 1.8 time = 880
.meas tran vdout0_15ck87 FIND v(dout0_15) AT=880.05n

* CHECK dout0_16 Vdout0_16ck87 = 1.8 time = 880
.meas tran vdout0_16ck87 FIND v(dout0_16) AT=880.05n

* CHECK dout0_17 Vdout0_17ck87 = 1.8 time = 880
.meas tran vdout0_17ck87 FIND v(dout0_17) AT=880.05n

* CHECK dout0_18 Vdout0_18ck87 = 0 time = 880
.meas tran vdout0_18ck87 FIND v(dout0_18) AT=880.05n

* CHECK dout0_19 Vdout0_19ck87 = 1.8 time = 880
.meas tran vdout0_19ck87 FIND v(dout0_19) AT=880.05n

* CHECK dout0_20 Vdout0_20ck87 = 1.8 time = 880
.meas tran vdout0_20ck87 FIND v(dout0_20) AT=880.05n

* CHECK dout0_21 Vdout0_21ck87 = 1.8 time = 880
.meas tran vdout0_21ck87 FIND v(dout0_21) AT=880.05n

* CHECK dout0_22 Vdout0_22ck87 = 0 time = 880
.meas tran vdout0_22ck87 FIND v(dout0_22) AT=880.05n

* CHECK dout0_23 Vdout0_23ck87 = 1.8 time = 880
.meas tran vdout0_23ck87 FIND v(dout0_23) AT=880.05n

* CHECK dout0_24 Vdout0_24ck87 = 0 time = 880
.meas tran vdout0_24ck87 FIND v(dout0_24) AT=880.05n

* CHECK dout0_25 Vdout0_25ck87 = 0 time = 880
.meas tran vdout0_25ck87 FIND v(dout0_25) AT=880.05n

* CHECK dout0_26 Vdout0_26ck87 = 1.8 time = 880
.meas tran vdout0_26ck87 FIND v(dout0_26) AT=880.05n

* CHECK dout0_27 Vdout0_27ck87 = 0 time = 880
.meas tran vdout0_27ck87 FIND v(dout0_27) AT=880.05n

* CHECK dout0_28 Vdout0_28ck87 = 1.8 time = 880
.meas tran vdout0_28ck87 FIND v(dout0_28) AT=880.05n

* CHECK dout0_29 Vdout0_29ck87 = 1.8 time = 880
.meas tran vdout0_29ck87 FIND v(dout0_29) AT=880.05n

* CHECK dout0_30 Vdout0_30ck87 = 0 time = 880
.meas tran vdout0_30ck87 FIND v(dout0_30) AT=880.05n

* CHECK dout0_31 Vdout0_31ck87 = 1.8 time = 880
.meas tran vdout0_31ck87 FIND v(dout0_31) AT=880.05n

* CHECK dout1_0 Vdout1_0ck87 = 1.8 time = 880
.meas tran vdout1_0ck87 FIND v(dout1_0) AT=880.05n

* CHECK dout1_1 Vdout1_1ck87 = 1.8 time = 880
.meas tran vdout1_1ck87 FIND v(dout1_1) AT=880.05n

* CHECK dout1_2 Vdout1_2ck87 = 1.8 time = 880
.meas tran vdout1_2ck87 FIND v(dout1_2) AT=880.05n

* CHECK dout1_3 Vdout1_3ck87 = 0 time = 880
.meas tran vdout1_3ck87 FIND v(dout1_3) AT=880.05n

* CHECK dout1_4 Vdout1_4ck87 = 0 time = 880
.meas tran vdout1_4ck87 FIND v(dout1_4) AT=880.05n

* CHECK dout1_5 Vdout1_5ck87 = 0 time = 880
.meas tran vdout1_5ck87 FIND v(dout1_5) AT=880.05n

* CHECK dout1_6 Vdout1_6ck87 = 0 time = 880
.meas tran vdout1_6ck87 FIND v(dout1_6) AT=880.05n

* CHECK dout1_7 Vdout1_7ck87 = 1.8 time = 880
.meas tran vdout1_7ck87 FIND v(dout1_7) AT=880.05n

* CHECK dout1_8 Vdout1_8ck87 = 0 time = 880
.meas tran vdout1_8ck87 FIND v(dout1_8) AT=880.05n

* CHECK dout1_9 Vdout1_9ck87 = 0 time = 880
.meas tran vdout1_9ck87 FIND v(dout1_9) AT=880.05n

* CHECK dout1_10 Vdout1_10ck87 = 0 time = 880
.meas tran vdout1_10ck87 FIND v(dout1_10) AT=880.05n

* CHECK dout1_11 Vdout1_11ck87 = 1.8 time = 880
.meas tran vdout1_11ck87 FIND v(dout1_11) AT=880.05n

* CHECK dout1_12 Vdout1_12ck87 = 0 time = 880
.meas tran vdout1_12ck87 FIND v(dout1_12) AT=880.05n

* CHECK dout1_13 Vdout1_13ck87 = 0 time = 880
.meas tran vdout1_13ck87 FIND v(dout1_13) AT=880.05n

* CHECK dout1_14 Vdout1_14ck87 = 0 time = 880
.meas tran vdout1_14ck87 FIND v(dout1_14) AT=880.05n

* CHECK dout1_15 Vdout1_15ck87 = 1.8 time = 880
.meas tran vdout1_15ck87 FIND v(dout1_15) AT=880.05n

* CHECK dout1_16 Vdout1_16ck87 = 1.8 time = 880
.meas tran vdout1_16ck87 FIND v(dout1_16) AT=880.05n

* CHECK dout1_17 Vdout1_17ck87 = 0 time = 880
.meas tran vdout1_17ck87 FIND v(dout1_17) AT=880.05n

* CHECK dout1_18 Vdout1_18ck87 = 1.8 time = 880
.meas tran vdout1_18ck87 FIND v(dout1_18) AT=880.05n

* CHECK dout1_19 Vdout1_19ck87 = 1.8 time = 880
.meas tran vdout1_19ck87 FIND v(dout1_19) AT=880.05n

* CHECK dout1_20 Vdout1_20ck87 = 0 time = 880
.meas tran vdout1_20ck87 FIND v(dout1_20) AT=880.05n

* CHECK dout1_21 Vdout1_21ck87 = 1.8 time = 880
.meas tran vdout1_21ck87 FIND v(dout1_21) AT=880.05n

* CHECK dout1_22 Vdout1_22ck87 = 0 time = 880
.meas tran vdout1_22ck87 FIND v(dout1_22) AT=880.05n

* CHECK dout1_23 Vdout1_23ck87 = 0 time = 880
.meas tran vdout1_23ck87 FIND v(dout1_23) AT=880.05n

* CHECK dout1_24 Vdout1_24ck87 = 1.8 time = 880
.meas tran vdout1_24ck87 FIND v(dout1_24) AT=880.05n

* CHECK dout1_25 Vdout1_25ck87 = 0 time = 880
.meas tran vdout1_25ck87 FIND v(dout1_25) AT=880.05n

* CHECK dout1_26 Vdout1_26ck87 = 1.8 time = 880
.meas tran vdout1_26ck87 FIND v(dout1_26) AT=880.05n

* CHECK dout1_27 Vdout1_27ck87 = 1.8 time = 880
.meas tran vdout1_27ck87 FIND v(dout1_27) AT=880.05n

* CHECK dout1_28 Vdout1_28ck87 = 1.8 time = 880
.meas tran vdout1_28ck87 FIND v(dout1_28) AT=880.05n

* CHECK dout1_29 Vdout1_29ck87 = 0 time = 880
.meas tran vdout1_29ck87 FIND v(dout1_29) AT=880.05n

* CHECK dout1_30 Vdout1_30ck87 = 0 time = 880
.meas tran vdout1_30ck87 FIND v(dout1_30) AT=880.05n

* CHECK dout1_31 Vdout1_31ck87 = 0 time = 880
.meas tran vdout1_31ck87 FIND v(dout1_31) AT=880.05n

* CHECK dout1_0 Vdout1_0ck89 = 1.8 time = 900
.meas tran vdout1_0ck89 FIND v(dout1_0) AT=900.05n

* CHECK dout1_1 Vdout1_1ck89 = 0 time = 900
.meas tran vdout1_1ck89 FIND v(dout1_1) AT=900.05n

* CHECK dout1_2 Vdout1_2ck89 = 0 time = 900
.meas tran vdout1_2ck89 FIND v(dout1_2) AT=900.05n

* CHECK dout1_3 Vdout1_3ck89 = 0 time = 900
.meas tran vdout1_3ck89 FIND v(dout1_3) AT=900.05n

* CHECK dout1_4 Vdout1_4ck89 = 1.8 time = 900
.meas tran vdout1_4ck89 FIND v(dout1_4) AT=900.05n

* CHECK dout1_5 Vdout1_5ck89 = 1.8 time = 900
.meas tran vdout1_5ck89 FIND v(dout1_5) AT=900.05n

* CHECK dout1_6 Vdout1_6ck89 = 1.8 time = 900
.meas tran vdout1_6ck89 FIND v(dout1_6) AT=900.05n

* CHECK dout1_7 Vdout1_7ck89 = 0 time = 900
.meas tran vdout1_7ck89 FIND v(dout1_7) AT=900.05n

* CHECK dout1_8 Vdout1_8ck89 = 0 time = 900
.meas tran vdout1_8ck89 FIND v(dout1_8) AT=900.05n

* CHECK dout1_9 Vdout1_9ck89 = 1.8 time = 900
.meas tran vdout1_9ck89 FIND v(dout1_9) AT=900.05n

* CHECK dout1_10 Vdout1_10ck89 = 1.8 time = 900
.meas tran vdout1_10ck89 FIND v(dout1_10) AT=900.05n

* CHECK dout1_11 Vdout1_11ck89 = 1.8 time = 900
.meas tran vdout1_11ck89 FIND v(dout1_11) AT=900.05n

* CHECK dout1_12 Vdout1_12ck89 = 0 time = 900
.meas tran vdout1_12ck89 FIND v(dout1_12) AT=900.05n

* CHECK dout1_13 Vdout1_13ck89 = 1.8 time = 900
.meas tran vdout1_13ck89 FIND v(dout1_13) AT=900.05n

* CHECK dout1_14 Vdout1_14ck89 = 0 time = 900
.meas tran vdout1_14ck89 FIND v(dout1_14) AT=900.05n

* CHECK dout1_15 Vdout1_15ck89 = 1.8 time = 900
.meas tran vdout1_15ck89 FIND v(dout1_15) AT=900.05n

* CHECK dout1_16 Vdout1_16ck89 = 0 time = 900
.meas tran vdout1_16ck89 FIND v(dout1_16) AT=900.05n

* CHECK dout1_17 Vdout1_17ck89 = 0 time = 900
.meas tran vdout1_17ck89 FIND v(dout1_17) AT=900.05n

* CHECK dout1_18 Vdout1_18ck89 = 0 time = 900
.meas tran vdout1_18ck89 FIND v(dout1_18) AT=900.05n

* CHECK dout1_19 Vdout1_19ck89 = 1.8 time = 900
.meas tran vdout1_19ck89 FIND v(dout1_19) AT=900.05n

* CHECK dout1_20 Vdout1_20ck89 = 0 time = 900
.meas tran vdout1_20ck89 FIND v(dout1_20) AT=900.05n

* CHECK dout1_21 Vdout1_21ck89 = 0 time = 900
.meas tran vdout1_21ck89 FIND v(dout1_21) AT=900.05n

* CHECK dout1_22 Vdout1_22ck89 = 0 time = 900
.meas tran vdout1_22ck89 FIND v(dout1_22) AT=900.05n

* CHECK dout1_23 Vdout1_23ck89 = 1.8 time = 900
.meas tran vdout1_23ck89 FIND v(dout1_23) AT=900.05n

* CHECK dout1_24 Vdout1_24ck89 = 1.8 time = 900
.meas tran vdout1_24ck89 FIND v(dout1_24) AT=900.05n

* CHECK dout1_25 Vdout1_25ck89 = 0 time = 900
.meas tran vdout1_25ck89 FIND v(dout1_25) AT=900.05n

* CHECK dout1_26 Vdout1_26ck89 = 1.8 time = 900
.meas tran vdout1_26ck89 FIND v(dout1_26) AT=900.05n

* CHECK dout1_27 Vdout1_27ck89 = 1.8 time = 900
.meas tran vdout1_27ck89 FIND v(dout1_27) AT=900.05n

* CHECK dout1_28 Vdout1_28ck89 = 1.8 time = 900
.meas tran vdout1_28ck89 FIND v(dout1_28) AT=900.05n

* CHECK dout1_29 Vdout1_29ck89 = 1.8 time = 900
.meas tran vdout1_29ck89 FIND v(dout1_29) AT=900.05n

* CHECK dout1_30 Vdout1_30ck89 = 1.8 time = 900
.meas tran vdout1_30ck89 FIND v(dout1_30) AT=900.05n

* CHECK dout1_31 Vdout1_31ck89 = 0 time = 900
.meas tran vdout1_31ck89 FIND v(dout1_31) AT=900.05n

* CHECK dout0_0 Vdout0_0ck90 = 1.8 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 1.8 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 1.8 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 0 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 1.8 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_8 Vdout0_8ck90 = 0 time = 910
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=910.05n

* CHECK dout0_9 Vdout0_9ck90 = 0 time = 910
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=910.05n

* CHECK dout0_10 Vdout0_10ck90 = 0 time = 910
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=910.05n

* CHECK dout0_11 Vdout0_11ck90 = 1.8 time = 910
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=910.05n

* CHECK dout0_12 Vdout0_12ck90 = 0 time = 910
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=910.05n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 910
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=910.05n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 910
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=910.05n

* CHECK dout0_15 Vdout0_15ck90 = 1.8 time = 910
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=910.05n

* CHECK dout0_16 Vdout0_16ck90 = 1.8 time = 910
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=910.05n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 910
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=910.05n

* CHECK dout0_18 Vdout0_18ck90 = 1.8 time = 910
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=910.05n

* CHECK dout0_19 Vdout0_19ck90 = 1.8 time = 910
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=910.05n

* CHECK dout0_20 Vdout0_20ck90 = 0 time = 910
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=910.05n

* CHECK dout0_21 Vdout0_21ck90 = 1.8 time = 910
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=910.05n

* CHECK dout0_22 Vdout0_22ck90 = 0 time = 910
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=910.05n

* CHECK dout0_23 Vdout0_23ck90 = 0 time = 910
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=910.05n

* CHECK dout0_24 Vdout0_24ck90 = 1.8 time = 910
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=910.05n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 910
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=910.05n

* CHECK dout0_26 Vdout0_26ck90 = 1.8 time = 910
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=910.05n

* CHECK dout0_27 Vdout0_27ck90 = 1.8 time = 910
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=910.05n

* CHECK dout0_28 Vdout0_28ck90 = 1.8 time = 910
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=910.05n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 910
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=910.05n

* CHECK dout0_30 Vdout0_30ck90 = 0 time = 910
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=910.05n

* CHECK dout0_31 Vdout0_31ck90 = 0 time = 910
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=910.05n

* CHECK dout1_0 Vdout1_0ck90 = 0 time = 910
.meas tran vdout1_0ck90 FIND v(dout1_0) AT=910.05n

* CHECK dout1_1 Vdout1_1ck90 = 0 time = 910
.meas tran vdout1_1ck90 FIND v(dout1_1) AT=910.05n

* CHECK dout1_2 Vdout1_2ck90 = 1.8 time = 910
.meas tran vdout1_2ck90 FIND v(dout1_2) AT=910.05n

* CHECK dout1_3 Vdout1_3ck90 = 0 time = 910
.meas tran vdout1_3ck90 FIND v(dout1_3) AT=910.05n

* CHECK dout1_4 Vdout1_4ck90 = 0 time = 910
.meas tran vdout1_4ck90 FIND v(dout1_4) AT=910.05n

* CHECK dout1_5 Vdout1_5ck90 = 1.8 time = 910
.meas tran vdout1_5ck90 FIND v(dout1_5) AT=910.05n

* CHECK dout1_6 Vdout1_6ck90 = 0 time = 910
.meas tran vdout1_6ck90 FIND v(dout1_6) AT=910.05n

* CHECK dout1_7 Vdout1_7ck90 = 1.8 time = 910
.meas tran vdout1_7ck90 FIND v(dout1_7) AT=910.05n

* CHECK dout1_8 Vdout1_8ck90 = 0 time = 910
.meas tran vdout1_8ck90 FIND v(dout1_8) AT=910.05n

* CHECK dout1_9 Vdout1_9ck90 = 0 time = 910
.meas tran vdout1_9ck90 FIND v(dout1_9) AT=910.05n

* CHECK dout1_10 Vdout1_10ck90 = 0 time = 910
.meas tran vdout1_10ck90 FIND v(dout1_10) AT=910.05n

* CHECK dout1_11 Vdout1_11ck90 = 0 time = 910
.meas tran vdout1_11ck90 FIND v(dout1_11) AT=910.05n

* CHECK dout1_12 Vdout1_12ck90 = 0 time = 910
.meas tran vdout1_12ck90 FIND v(dout1_12) AT=910.05n

* CHECK dout1_13 Vdout1_13ck90 = 0 time = 910
.meas tran vdout1_13ck90 FIND v(dout1_13) AT=910.05n

* CHECK dout1_14 Vdout1_14ck90 = 0 time = 910
.meas tran vdout1_14ck90 FIND v(dout1_14) AT=910.05n

* CHECK dout1_15 Vdout1_15ck90 = 0 time = 910
.meas tran vdout1_15ck90 FIND v(dout1_15) AT=910.05n

* CHECK dout1_16 Vdout1_16ck90 = 0 time = 910
.meas tran vdout1_16ck90 FIND v(dout1_16) AT=910.05n

* CHECK dout1_17 Vdout1_17ck90 = 0 time = 910
.meas tran vdout1_17ck90 FIND v(dout1_17) AT=910.05n

* CHECK dout1_18 Vdout1_18ck90 = 0 time = 910
.meas tran vdout1_18ck90 FIND v(dout1_18) AT=910.05n

* CHECK dout1_19 Vdout1_19ck90 = 1.8 time = 910
.meas tran vdout1_19ck90 FIND v(dout1_19) AT=910.05n

* CHECK dout1_20 Vdout1_20ck90 = 1.8 time = 910
.meas tran vdout1_20ck90 FIND v(dout1_20) AT=910.05n

* CHECK dout1_21 Vdout1_21ck90 = 1.8 time = 910
.meas tran vdout1_21ck90 FIND v(dout1_21) AT=910.05n

* CHECK dout1_22 Vdout1_22ck90 = 0 time = 910
.meas tran vdout1_22ck90 FIND v(dout1_22) AT=910.05n

* CHECK dout1_23 Vdout1_23ck90 = 0 time = 910
.meas tran vdout1_23ck90 FIND v(dout1_23) AT=910.05n

* CHECK dout1_24 Vdout1_24ck90 = 0 time = 910
.meas tran vdout1_24ck90 FIND v(dout1_24) AT=910.05n

* CHECK dout1_25 Vdout1_25ck90 = 0 time = 910
.meas tran vdout1_25ck90 FIND v(dout1_25) AT=910.05n

* CHECK dout1_26 Vdout1_26ck90 = 0 time = 910
.meas tran vdout1_26ck90 FIND v(dout1_26) AT=910.05n

* CHECK dout1_27 Vdout1_27ck90 = 1.8 time = 910
.meas tran vdout1_27ck90 FIND v(dout1_27) AT=910.05n

* CHECK dout1_28 Vdout1_28ck90 = 1.8 time = 910
.meas tran vdout1_28ck90 FIND v(dout1_28) AT=910.05n

* CHECK dout1_29 Vdout1_29ck90 = 0 time = 910
.meas tran vdout1_29ck90 FIND v(dout1_29) AT=910.05n

* CHECK dout1_30 Vdout1_30ck90 = 0 time = 910
.meas tran vdout1_30ck90 FIND v(dout1_30) AT=910.05n

* CHECK dout1_31 Vdout1_31ck90 = 1.8 time = 910
.meas tran vdout1_31ck90 FIND v(dout1_31) AT=910.05n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 920
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=920.05n

* CHECK dout0_1 Vdout0_1ck91 = 1.8 time = 920
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=920.05n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 920
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=920.05n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 920
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=920.05n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 920
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=920.05n

* CHECK dout0_5 Vdout0_5ck91 = 1.8 time = 920
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=920.05n

* CHECK dout0_6 Vdout0_6ck91 = 1.8 time = 920
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=920.05n

* CHECK dout0_7 Vdout0_7ck91 = 1.8 time = 920
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=920.05n

* CHECK dout0_8 Vdout0_8ck91 = 1.8 time = 920
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=920.05n

* CHECK dout0_9 Vdout0_9ck91 = 0 time = 920
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=920.05n

* CHECK dout0_10 Vdout0_10ck91 = 1.8 time = 920
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=920.05n

* CHECK dout0_11 Vdout0_11ck91 = 1.8 time = 920
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=920.05n

* CHECK dout0_12 Vdout0_12ck91 = 1.8 time = 920
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=920.05n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 920
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=920.05n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 920
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=920.05n

* CHECK dout0_15 Vdout0_15ck91 = 1.8 time = 920
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=920.05n

* CHECK dout0_16 Vdout0_16ck91 = 1.8 time = 920
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=920.05n

* CHECK dout0_17 Vdout0_17ck91 = 1.8 time = 920
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=920.05n

* CHECK dout0_18 Vdout0_18ck91 = 0 time = 920
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=920.05n

* CHECK dout0_19 Vdout0_19ck91 = 1.8 time = 920
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=920.05n

* CHECK dout0_20 Vdout0_20ck91 = 1.8 time = 920
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=920.05n

* CHECK dout0_21 Vdout0_21ck91 = 1.8 time = 920
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=920.05n

* CHECK dout0_22 Vdout0_22ck91 = 0 time = 920
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=920.05n

* CHECK dout0_23 Vdout0_23ck91 = 1.8 time = 920
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=920.05n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 920
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=920.05n

* CHECK dout0_25 Vdout0_25ck91 = 0 time = 920
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=920.05n

* CHECK dout0_26 Vdout0_26ck91 = 1.8 time = 920
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=920.05n

* CHECK dout0_27 Vdout0_27ck91 = 0 time = 920
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=920.05n

* CHECK dout0_28 Vdout0_28ck91 = 1.8 time = 920
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=920.05n

* CHECK dout0_29 Vdout0_29ck91 = 1.8 time = 920
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=920.05n

* CHECK dout0_30 Vdout0_30ck91 = 0 time = 920
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=920.05n

* CHECK dout0_31 Vdout0_31ck91 = 1.8 time = 920
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=920.05n

* CHECK dout0_0 Vdout0_0ck92 = 1.8 time = 930
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=930.05n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 930
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=930.05n

* CHECK dout0_2 Vdout0_2ck92 = 1.8 time = 930
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=930.05n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 930
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=930.05n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 930
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=930.05n

* CHECK dout0_5 Vdout0_5ck92 = 0 time = 930
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=930.05n

* CHECK dout0_6 Vdout0_6ck92 = 0 time = 930
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=930.05n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 930
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=930.05n

* CHECK dout0_8 Vdout0_8ck92 = 0 time = 930
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=930.05n

* CHECK dout0_9 Vdout0_9ck92 = 0 time = 930
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=930.05n

* CHECK dout0_10 Vdout0_10ck92 = 0 time = 930
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=930.05n

* CHECK dout0_11 Vdout0_11ck92 = 1.8 time = 930
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=930.05n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 930
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=930.05n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 930
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=930.05n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 930
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=930.05n

* CHECK dout0_15 Vdout0_15ck92 = 1.8 time = 930
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=930.05n

* CHECK dout0_16 Vdout0_16ck92 = 1.8 time = 930
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=930.05n

* CHECK dout0_17 Vdout0_17ck92 = 0 time = 930
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=930.05n

* CHECK dout0_18 Vdout0_18ck92 = 1.8 time = 930
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=930.05n

* CHECK dout0_19 Vdout0_19ck92 = 1.8 time = 930
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=930.05n

* CHECK dout0_20 Vdout0_20ck92 = 0 time = 930
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=930.05n

* CHECK dout0_21 Vdout0_21ck92 = 1.8 time = 930
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=930.05n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 930
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=930.05n

* CHECK dout0_23 Vdout0_23ck92 = 0 time = 930
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=930.05n

* CHECK dout0_24 Vdout0_24ck92 = 1.8 time = 930
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=930.05n

* CHECK dout0_25 Vdout0_25ck92 = 0 time = 930
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=930.05n

* CHECK dout0_26 Vdout0_26ck92 = 1.8 time = 930
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=930.05n

* CHECK dout0_27 Vdout0_27ck92 = 1.8 time = 930
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=930.05n

* CHECK dout0_28 Vdout0_28ck92 = 1.8 time = 930
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=930.05n

* CHECK dout0_29 Vdout0_29ck92 = 0 time = 930
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=930.05n

* CHECK dout0_30 Vdout0_30ck92 = 0 time = 930
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=930.05n

* CHECK dout0_31 Vdout0_31ck92 = 0 time = 930
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=930.05n

* CHECK dout1_0 Vdout1_0ck94 = 1.8 time = 950
.meas tran vdout1_0ck94 FIND v(dout1_0) AT=950.05n

* CHECK dout1_1 Vdout1_1ck94 = 0 time = 950
.meas tran vdout1_1ck94 FIND v(dout1_1) AT=950.05n

* CHECK dout1_2 Vdout1_2ck94 = 0 time = 950
.meas tran vdout1_2ck94 FIND v(dout1_2) AT=950.05n

* CHECK dout1_3 Vdout1_3ck94 = 0 time = 950
.meas tran vdout1_3ck94 FIND v(dout1_3) AT=950.05n

* CHECK dout1_4 Vdout1_4ck94 = 1.8 time = 950
.meas tran vdout1_4ck94 FIND v(dout1_4) AT=950.05n

* CHECK dout1_5 Vdout1_5ck94 = 1.8 time = 950
.meas tran vdout1_5ck94 FIND v(dout1_5) AT=950.05n

* CHECK dout1_6 Vdout1_6ck94 = 1.8 time = 950
.meas tran vdout1_6ck94 FIND v(dout1_6) AT=950.05n

* CHECK dout1_7 Vdout1_7ck94 = 0 time = 950
.meas tran vdout1_7ck94 FIND v(dout1_7) AT=950.05n

* CHECK dout1_8 Vdout1_8ck94 = 0 time = 950
.meas tran vdout1_8ck94 FIND v(dout1_8) AT=950.05n

* CHECK dout1_9 Vdout1_9ck94 = 1.8 time = 950
.meas tran vdout1_9ck94 FIND v(dout1_9) AT=950.05n

* CHECK dout1_10 Vdout1_10ck94 = 1.8 time = 950
.meas tran vdout1_10ck94 FIND v(dout1_10) AT=950.05n

* CHECK dout1_11 Vdout1_11ck94 = 1.8 time = 950
.meas tran vdout1_11ck94 FIND v(dout1_11) AT=950.05n

* CHECK dout1_12 Vdout1_12ck94 = 0 time = 950
.meas tran vdout1_12ck94 FIND v(dout1_12) AT=950.05n

* CHECK dout1_13 Vdout1_13ck94 = 1.8 time = 950
.meas tran vdout1_13ck94 FIND v(dout1_13) AT=950.05n

* CHECK dout1_14 Vdout1_14ck94 = 0 time = 950
.meas tran vdout1_14ck94 FIND v(dout1_14) AT=950.05n

* CHECK dout1_15 Vdout1_15ck94 = 1.8 time = 950
.meas tran vdout1_15ck94 FIND v(dout1_15) AT=950.05n

* CHECK dout1_16 Vdout1_16ck94 = 0 time = 950
.meas tran vdout1_16ck94 FIND v(dout1_16) AT=950.05n

* CHECK dout1_17 Vdout1_17ck94 = 0 time = 950
.meas tran vdout1_17ck94 FIND v(dout1_17) AT=950.05n

* CHECK dout1_18 Vdout1_18ck94 = 0 time = 950
.meas tran vdout1_18ck94 FIND v(dout1_18) AT=950.05n

* CHECK dout1_19 Vdout1_19ck94 = 1.8 time = 950
.meas tran vdout1_19ck94 FIND v(dout1_19) AT=950.05n

* CHECK dout1_20 Vdout1_20ck94 = 0 time = 950
.meas tran vdout1_20ck94 FIND v(dout1_20) AT=950.05n

* CHECK dout1_21 Vdout1_21ck94 = 0 time = 950
.meas tran vdout1_21ck94 FIND v(dout1_21) AT=950.05n

* CHECK dout1_22 Vdout1_22ck94 = 0 time = 950
.meas tran vdout1_22ck94 FIND v(dout1_22) AT=950.05n

* CHECK dout1_23 Vdout1_23ck94 = 1.8 time = 950
.meas tran vdout1_23ck94 FIND v(dout1_23) AT=950.05n

* CHECK dout1_24 Vdout1_24ck94 = 1.8 time = 950
.meas tran vdout1_24ck94 FIND v(dout1_24) AT=950.05n

* CHECK dout1_25 Vdout1_25ck94 = 0 time = 950
.meas tran vdout1_25ck94 FIND v(dout1_25) AT=950.05n

* CHECK dout1_26 Vdout1_26ck94 = 1.8 time = 950
.meas tran vdout1_26ck94 FIND v(dout1_26) AT=950.05n

* CHECK dout1_27 Vdout1_27ck94 = 1.8 time = 950
.meas tran vdout1_27ck94 FIND v(dout1_27) AT=950.05n

* CHECK dout1_28 Vdout1_28ck94 = 1.8 time = 950
.meas tran vdout1_28ck94 FIND v(dout1_28) AT=950.05n

* CHECK dout1_29 Vdout1_29ck94 = 1.8 time = 950
.meas tran vdout1_29ck94 FIND v(dout1_29) AT=950.05n

* CHECK dout1_30 Vdout1_30ck94 = 1.8 time = 950
.meas tran vdout1_30ck94 FIND v(dout1_30) AT=950.05n

* CHECK dout1_31 Vdout1_31ck94 = 0 time = 950
.meas tran vdout1_31ck94 FIND v(dout1_31) AT=950.05n

* CHECK dout0_0 Vdout0_0ck95 = 1.8 time = 960
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=960.05n

* CHECK dout0_1 Vdout0_1ck95 = 1.8 time = 960
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=960.05n

* CHECK dout0_2 Vdout0_2ck95 = 1.8 time = 960
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=960.05n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 960
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=960.05n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 960
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=960.05n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 960
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=960.05n

* CHECK dout0_6 Vdout0_6ck95 = 0 time = 960
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=960.05n

* CHECK dout0_7 Vdout0_7ck95 = 1.8 time = 960
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=960.05n

* CHECK dout0_8 Vdout0_8ck95 = 0 time = 960
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=960.05n

* CHECK dout0_9 Vdout0_9ck95 = 0 time = 960
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=960.05n

* CHECK dout0_10 Vdout0_10ck95 = 0 time = 960
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=960.05n

* CHECK dout0_11 Vdout0_11ck95 = 1.8 time = 960
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=960.05n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 960
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=960.05n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 960
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=960.05n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 960
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=960.05n

* CHECK dout0_15 Vdout0_15ck95 = 1.8 time = 960
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=960.05n

* CHECK dout0_16 Vdout0_16ck95 = 1.8 time = 960
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=960.05n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 960
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=960.05n

* CHECK dout0_18 Vdout0_18ck95 = 1.8 time = 960
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=960.05n

* CHECK dout0_19 Vdout0_19ck95 = 1.8 time = 960
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=960.05n

* CHECK dout0_20 Vdout0_20ck95 = 0 time = 960
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=960.05n

* CHECK dout0_21 Vdout0_21ck95 = 1.8 time = 960
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=960.05n

* CHECK dout0_22 Vdout0_22ck95 = 0 time = 960
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=960.05n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 960
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=960.05n

* CHECK dout0_24 Vdout0_24ck95 = 1.8 time = 960
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=960.05n

* CHECK dout0_25 Vdout0_25ck95 = 0 time = 960
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=960.05n

* CHECK dout0_26 Vdout0_26ck95 = 1.8 time = 960
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=960.05n

* CHECK dout0_27 Vdout0_27ck95 = 1.8 time = 960
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=960.05n

* CHECK dout0_28 Vdout0_28ck95 = 1.8 time = 960
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=960.05n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 960
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=960.05n

* CHECK dout0_30 Vdout0_30ck95 = 0 time = 960
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=960.05n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 960
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=960.05n

* CHECK dout1_0 Vdout1_0ck96 = 0 time = 970
.meas tran vdout1_0ck96 FIND v(dout1_0) AT=970.05n

* CHECK dout1_1 Vdout1_1ck96 = 0 time = 970
.meas tran vdout1_1ck96 FIND v(dout1_1) AT=970.05n

* CHECK dout1_2 Vdout1_2ck96 = 1.8 time = 970
.meas tran vdout1_2ck96 FIND v(dout1_2) AT=970.05n

* CHECK dout1_3 Vdout1_3ck96 = 0 time = 970
.meas tran vdout1_3ck96 FIND v(dout1_3) AT=970.05n

* CHECK dout1_4 Vdout1_4ck96 = 0 time = 970
.meas tran vdout1_4ck96 FIND v(dout1_4) AT=970.05n

* CHECK dout1_5 Vdout1_5ck96 = 1.8 time = 970
.meas tran vdout1_5ck96 FIND v(dout1_5) AT=970.05n

* CHECK dout1_6 Vdout1_6ck96 = 0 time = 970
.meas tran vdout1_6ck96 FIND v(dout1_6) AT=970.05n

* CHECK dout1_7 Vdout1_7ck96 = 1.8 time = 970
.meas tran vdout1_7ck96 FIND v(dout1_7) AT=970.05n

* CHECK dout1_8 Vdout1_8ck96 = 0 time = 970
.meas tran vdout1_8ck96 FIND v(dout1_8) AT=970.05n

* CHECK dout1_9 Vdout1_9ck96 = 0 time = 970
.meas tran vdout1_9ck96 FIND v(dout1_9) AT=970.05n

* CHECK dout1_10 Vdout1_10ck96 = 0 time = 970
.meas tran vdout1_10ck96 FIND v(dout1_10) AT=970.05n

* CHECK dout1_11 Vdout1_11ck96 = 0 time = 970
.meas tran vdout1_11ck96 FIND v(dout1_11) AT=970.05n

* CHECK dout1_12 Vdout1_12ck96 = 0 time = 970
.meas tran vdout1_12ck96 FIND v(dout1_12) AT=970.05n

* CHECK dout1_13 Vdout1_13ck96 = 0 time = 970
.meas tran vdout1_13ck96 FIND v(dout1_13) AT=970.05n

* CHECK dout1_14 Vdout1_14ck96 = 0 time = 970
.meas tran vdout1_14ck96 FIND v(dout1_14) AT=970.05n

* CHECK dout1_15 Vdout1_15ck96 = 0 time = 970
.meas tran vdout1_15ck96 FIND v(dout1_15) AT=970.05n

* CHECK dout1_16 Vdout1_16ck96 = 0 time = 970
.meas tran vdout1_16ck96 FIND v(dout1_16) AT=970.05n

* CHECK dout1_17 Vdout1_17ck96 = 0 time = 970
.meas tran vdout1_17ck96 FIND v(dout1_17) AT=970.05n

* CHECK dout1_18 Vdout1_18ck96 = 0 time = 970
.meas tran vdout1_18ck96 FIND v(dout1_18) AT=970.05n

* CHECK dout1_19 Vdout1_19ck96 = 1.8 time = 970
.meas tran vdout1_19ck96 FIND v(dout1_19) AT=970.05n

* CHECK dout1_20 Vdout1_20ck96 = 1.8 time = 970
.meas tran vdout1_20ck96 FIND v(dout1_20) AT=970.05n

* CHECK dout1_21 Vdout1_21ck96 = 1.8 time = 970
.meas tran vdout1_21ck96 FIND v(dout1_21) AT=970.05n

* CHECK dout1_22 Vdout1_22ck96 = 0 time = 970
.meas tran vdout1_22ck96 FIND v(dout1_22) AT=970.05n

* CHECK dout1_23 Vdout1_23ck96 = 0 time = 970
.meas tran vdout1_23ck96 FIND v(dout1_23) AT=970.05n

* CHECK dout1_24 Vdout1_24ck96 = 0 time = 970
.meas tran vdout1_24ck96 FIND v(dout1_24) AT=970.05n

* CHECK dout1_25 Vdout1_25ck96 = 0 time = 970
.meas tran vdout1_25ck96 FIND v(dout1_25) AT=970.05n

* CHECK dout1_26 Vdout1_26ck96 = 0 time = 970
.meas tran vdout1_26ck96 FIND v(dout1_26) AT=970.05n

* CHECK dout1_27 Vdout1_27ck96 = 1.8 time = 970
.meas tran vdout1_27ck96 FIND v(dout1_27) AT=970.05n

* CHECK dout1_28 Vdout1_28ck96 = 1.8 time = 970
.meas tran vdout1_28ck96 FIND v(dout1_28) AT=970.05n

* CHECK dout1_29 Vdout1_29ck96 = 0 time = 970
.meas tran vdout1_29ck96 FIND v(dout1_29) AT=970.05n

* CHECK dout1_30 Vdout1_30ck96 = 0 time = 970
.meas tran vdout1_30ck96 FIND v(dout1_30) AT=970.05n

* CHECK dout1_31 Vdout1_31ck96 = 1.8 time = 970
.meas tran vdout1_31ck96 FIND v(dout1_31) AT=970.05n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 980
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=980.05n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 980
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=980.05n

* CHECK dout0_2 Vdout0_2ck97 = 1.8 time = 980
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=980.05n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 980
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=980.05n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 980
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=980.05n

* CHECK dout0_5 Vdout0_5ck97 = 1.8 time = 980
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=980.05n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 980
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=980.05n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 980
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=980.05n

* CHECK dout0_8 Vdout0_8ck97 = 0 time = 980
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=980.05n

* CHECK dout0_9 Vdout0_9ck97 = 0 time = 980
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=980.05n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 980
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=980.05n

* CHECK dout0_11 Vdout0_11ck97 = 0 time = 980
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=980.05n

* CHECK dout0_12 Vdout0_12ck97 = 0 time = 980
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=980.05n

* CHECK dout0_13 Vdout0_13ck97 = 0 time = 980
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=980.05n

* CHECK dout0_14 Vdout0_14ck97 = 0 time = 980
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=980.05n

* CHECK dout0_15 Vdout0_15ck97 = 0 time = 980
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=980.05n

* CHECK dout0_16 Vdout0_16ck97 = 0 time = 980
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=980.05n

* CHECK dout0_17 Vdout0_17ck97 = 0 time = 980
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=980.05n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 980
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=980.05n

* CHECK dout0_19 Vdout0_19ck97 = 1.8 time = 980
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=980.05n

* CHECK dout0_20 Vdout0_20ck97 = 1.8 time = 980
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=980.05n

* CHECK dout0_21 Vdout0_21ck97 = 1.8 time = 980
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=980.05n

* CHECK dout0_22 Vdout0_22ck97 = 0 time = 980
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=980.05n

* CHECK dout0_23 Vdout0_23ck97 = 0 time = 980
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=980.05n

* CHECK dout0_24 Vdout0_24ck97 = 0 time = 980
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=980.05n

* CHECK dout0_25 Vdout0_25ck97 = 0 time = 980
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=980.05n

* CHECK dout0_26 Vdout0_26ck97 = 0 time = 980
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=980.05n

* CHECK dout0_27 Vdout0_27ck97 = 1.8 time = 980
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=980.05n

* CHECK dout0_28 Vdout0_28ck97 = 1.8 time = 980
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=980.05n

* CHECK dout0_29 Vdout0_29ck97 = 0 time = 980
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=980.05n

* CHECK dout0_30 Vdout0_30ck97 = 0 time = 980
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=980.05n

* CHECK dout0_31 Vdout0_31ck97 = 1.8 time = 980
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=980.05n

* CHECK dout0_0 Vdout0_0ck98 = 1.8 time = 990
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=990.05n

* CHECK dout0_1 Vdout0_1ck98 = 1.8 time = 990
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=990.05n

* CHECK dout0_2 Vdout0_2ck98 = 1.8 time = 990
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=990.05n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 990
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=990.05n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 990
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=990.05n

* CHECK dout0_5 Vdout0_5ck98 = 0 time = 990
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=990.05n

* CHECK dout0_6 Vdout0_6ck98 = 0 time = 990
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=990.05n

* CHECK dout0_7 Vdout0_7ck98 = 1.8 time = 990
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=990.05n

* CHECK dout0_8 Vdout0_8ck98 = 0 time = 990
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=990.05n

* CHECK dout0_9 Vdout0_9ck98 = 0 time = 990
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=990.05n

* CHECK dout0_10 Vdout0_10ck98 = 0 time = 990
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=990.05n

* CHECK dout0_11 Vdout0_11ck98 = 1.8 time = 990
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=990.05n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 990
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=990.05n

* CHECK dout0_13 Vdout0_13ck98 = 0 time = 990
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=990.05n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 990
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=990.05n

* CHECK dout0_15 Vdout0_15ck98 = 1.8 time = 990
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=990.05n

* CHECK dout0_16 Vdout0_16ck98 = 1.8 time = 990
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=990.05n

* CHECK dout0_17 Vdout0_17ck98 = 0 time = 990
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=990.05n

* CHECK dout0_18 Vdout0_18ck98 = 1.8 time = 990
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=990.05n

* CHECK dout0_19 Vdout0_19ck98 = 1.8 time = 990
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=990.05n

* CHECK dout0_20 Vdout0_20ck98 = 0 time = 990
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=990.05n

* CHECK dout0_21 Vdout0_21ck98 = 1.8 time = 990
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=990.05n

* CHECK dout0_22 Vdout0_22ck98 = 0 time = 990
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=990.05n

* CHECK dout0_23 Vdout0_23ck98 = 0 time = 990
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=990.05n

* CHECK dout0_24 Vdout0_24ck98 = 1.8 time = 990
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=990.05n

* CHECK dout0_25 Vdout0_25ck98 = 0 time = 990
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=990.05n

* CHECK dout0_26 Vdout0_26ck98 = 1.8 time = 990
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=990.05n

* CHECK dout0_27 Vdout0_27ck98 = 1.8 time = 990
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=990.05n

* CHECK dout0_28 Vdout0_28ck98 = 1.8 time = 990
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=990.05n

* CHECK dout0_29 Vdout0_29ck98 = 0 time = 990
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=990.05n

* CHECK dout0_30 Vdout0_30ck98 = 0 time = 990
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=990.05n

* CHECK dout0_31 Vdout0_31ck98 = 0 time = 990
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=990.05n

* CHECK dout1_0 Vdout1_0ck98 = 0 time = 990
.meas tran vdout1_0ck98 FIND v(dout1_0) AT=990.05n

* CHECK dout1_1 Vdout1_1ck98 = 0 time = 990
.meas tran vdout1_1ck98 FIND v(dout1_1) AT=990.05n

* CHECK dout1_2 Vdout1_2ck98 = 1.8 time = 990
.meas tran vdout1_2ck98 FIND v(dout1_2) AT=990.05n

* CHECK dout1_3 Vdout1_3ck98 = 0 time = 990
.meas tran vdout1_3ck98 FIND v(dout1_3) AT=990.05n

* CHECK dout1_4 Vdout1_4ck98 = 0 time = 990
.meas tran vdout1_4ck98 FIND v(dout1_4) AT=990.05n

* CHECK dout1_5 Vdout1_5ck98 = 1.8 time = 990
.meas tran vdout1_5ck98 FIND v(dout1_5) AT=990.05n

* CHECK dout1_6 Vdout1_6ck98 = 0 time = 990
.meas tran vdout1_6ck98 FIND v(dout1_6) AT=990.05n

* CHECK dout1_7 Vdout1_7ck98 = 1.8 time = 990
.meas tran vdout1_7ck98 FIND v(dout1_7) AT=990.05n

* CHECK dout1_8 Vdout1_8ck98 = 0 time = 990
.meas tran vdout1_8ck98 FIND v(dout1_8) AT=990.05n

* CHECK dout1_9 Vdout1_9ck98 = 0 time = 990
.meas tran vdout1_9ck98 FIND v(dout1_9) AT=990.05n

* CHECK dout1_10 Vdout1_10ck98 = 0 time = 990
.meas tran vdout1_10ck98 FIND v(dout1_10) AT=990.05n

* CHECK dout1_11 Vdout1_11ck98 = 0 time = 990
.meas tran vdout1_11ck98 FIND v(dout1_11) AT=990.05n

* CHECK dout1_12 Vdout1_12ck98 = 0 time = 990
.meas tran vdout1_12ck98 FIND v(dout1_12) AT=990.05n

* CHECK dout1_13 Vdout1_13ck98 = 0 time = 990
.meas tran vdout1_13ck98 FIND v(dout1_13) AT=990.05n

* CHECK dout1_14 Vdout1_14ck98 = 0 time = 990
.meas tran vdout1_14ck98 FIND v(dout1_14) AT=990.05n

* CHECK dout1_15 Vdout1_15ck98 = 0 time = 990
.meas tran vdout1_15ck98 FIND v(dout1_15) AT=990.05n

* CHECK dout1_16 Vdout1_16ck98 = 0 time = 990
.meas tran vdout1_16ck98 FIND v(dout1_16) AT=990.05n

* CHECK dout1_17 Vdout1_17ck98 = 0 time = 990
.meas tran vdout1_17ck98 FIND v(dout1_17) AT=990.05n

* CHECK dout1_18 Vdout1_18ck98 = 0 time = 990
.meas tran vdout1_18ck98 FIND v(dout1_18) AT=990.05n

* CHECK dout1_19 Vdout1_19ck98 = 1.8 time = 990
.meas tran vdout1_19ck98 FIND v(dout1_19) AT=990.05n

* CHECK dout1_20 Vdout1_20ck98 = 1.8 time = 990
.meas tran vdout1_20ck98 FIND v(dout1_20) AT=990.05n

* CHECK dout1_21 Vdout1_21ck98 = 1.8 time = 990
.meas tran vdout1_21ck98 FIND v(dout1_21) AT=990.05n

* CHECK dout1_22 Vdout1_22ck98 = 0 time = 990
.meas tran vdout1_22ck98 FIND v(dout1_22) AT=990.05n

* CHECK dout1_23 Vdout1_23ck98 = 0 time = 990
.meas tran vdout1_23ck98 FIND v(dout1_23) AT=990.05n

* CHECK dout1_24 Vdout1_24ck98 = 0 time = 990
.meas tran vdout1_24ck98 FIND v(dout1_24) AT=990.05n

* CHECK dout1_25 Vdout1_25ck98 = 0 time = 990
.meas tran vdout1_25ck98 FIND v(dout1_25) AT=990.05n

* CHECK dout1_26 Vdout1_26ck98 = 0 time = 990
.meas tran vdout1_26ck98 FIND v(dout1_26) AT=990.05n

* CHECK dout1_27 Vdout1_27ck98 = 1.8 time = 990
.meas tran vdout1_27ck98 FIND v(dout1_27) AT=990.05n

* CHECK dout1_28 Vdout1_28ck98 = 1.8 time = 990
.meas tran vdout1_28ck98 FIND v(dout1_28) AT=990.05n

* CHECK dout1_29 Vdout1_29ck98 = 0 time = 990
.meas tran vdout1_29ck98 FIND v(dout1_29) AT=990.05n

* CHECK dout1_30 Vdout1_30ck98 = 0 time = 990
.meas tran vdout1_30ck98 FIND v(dout1_30) AT=990.05n

* CHECK dout1_31 Vdout1_31ck98 = 1.8 time = 990
.meas tran vdout1_31ck98 FIND v(dout1_31) AT=990.05n

* CHECK dout1_0 Vdout1_0ck100 = 1.8 time = 1010
.meas tran vdout1_0ck100 FIND v(dout1_0) AT=1010.05n

* CHECK dout1_1 Vdout1_1ck100 = 1.8 time = 1010
.meas tran vdout1_1ck100 FIND v(dout1_1) AT=1010.05n

* CHECK dout1_2 Vdout1_2ck100 = 1.8 time = 1010
.meas tran vdout1_2ck100 FIND v(dout1_2) AT=1010.05n

* CHECK dout1_3 Vdout1_3ck100 = 0 time = 1010
.meas tran vdout1_3ck100 FIND v(dout1_3) AT=1010.05n

* CHECK dout1_4 Vdout1_4ck100 = 0 time = 1010
.meas tran vdout1_4ck100 FIND v(dout1_4) AT=1010.05n

* CHECK dout1_5 Vdout1_5ck100 = 0 time = 1010
.meas tran vdout1_5ck100 FIND v(dout1_5) AT=1010.05n

* CHECK dout1_6 Vdout1_6ck100 = 0 time = 1010
.meas tran vdout1_6ck100 FIND v(dout1_6) AT=1010.05n

* CHECK dout1_7 Vdout1_7ck100 = 1.8 time = 1010
.meas tran vdout1_7ck100 FIND v(dout1_7) AT=1010.05n

* CHECK dout1_8 Vdout1_8ck100 = 0 time = 1010
.meas tran vdout1_8ck100 FIND v(dout1_8) AT=1010.05n

* CHECK dout1_9 Vdout1_9ck100 = 0 time = 1010
.meas tran vdout1_9ck100 FIND v(dout1_9) AT=1010.05n

* CHECK dout1_10 Vdout1_10ck100 = 0 time = 1010
.meas tran vdout1_10ck100 FIND v(dout1_10) AT=1010.05n

* CHECK dout1_11 Vdout1_11ck100 = 1.8 time = 1010
.meas tran vdout1_11ck100 FIND v(dout1_11) AT=1010.05n

* CHECK dout1_12 Vdout1_12ck100 = 0 time = 1010
.meas tran vdout1_12ck100 FIND v(dout1_12) AT=1010.05n

* CHECK dout1_13 Vdout1_13ck100 = 0 time = 1010
.meas tran vdout1_13ck100 FIND v(dout1_13) AT=1010.05n

* CHECK dout1_14 Vdout1_14ck100 = 0 time = 1010
.meas tran vdout1_14ck100 FIND v(dout1_14) AT=1010.05n

* CHECK dout1_15 Vdout1_15ck100 = 1.8 time = 1010
.meas tran vdout1_15ck100 FIND v(dout1_15) AT=1010.05n

* CHECK dout1_16 Vdout1_16ck100 = 1.8 time = 1010
.meas tran vdout1_16ck100 FIND v(dout1_16) AT=1010.05n

* CHECK dout1_17 Vdout1_17ck100 = 0 time = 1010
.meas tran vdout1_17ck100 FIND v(dout1_17) AT=1010.05n

* CHECK dout1_18 Vdout1_18ck100 = 1.8 time = 1010
.meas tran vdout1_18ck100 FIND v(dout1_18) AT=1010.05n

* CHECK dout1_19 Vdout1_19ck100 = 1.8 time = 1010
.meas tran vdout1_19ck100 FIND v(dout1_19) AT=1010.05n

* CHECK dout1_20 Vdout1_20ck100 = 0 time = 1010
.meas tran vdout1_20ck100 FIND v(dout1_20) AT=1010.05n

* CHECK dout1_21 Vdout1_21ck100 = 1.8 time = 1010
.meas tran vdout1_21ck100 FIND v(dout1_21) AT=1010.05n

* CHECK dout1_22 Vdout1_22ck100 = 0 time = 1010
.meas tran vdout1_22ck100 FIND v(dout1_22) AT=1010.05n

* CHECK dout1_23 Vdout1_23ck100 = 0 time = 1010
.meas tran vdout1_23ck100 FIND v(dout1_23) AT=1010.05n

* CHECK dout1_24 Vdout1_24ck100 = 1.8 time = 1010
.meas tran vdout1_24ck100 FIND v(dout1_24) AT=1010.05n

* CHECK dout1_25 Vdout1_25ck100 = 0 time = 1010
.meas tran vdout1_25ck100 FIND v(dout1_25) AT=1010.05n

* CHECK dout1_26 Vdout1_26ck100 = 1.8 time = 1010
.meas tran vdout1_26ck100 FIND v(dout1_26) AT=1010.05n

* CHECK dout1_27 Vdout1_27ck100 = 1.8 time = 1010
.meas tran vdout1_27ck100 FIND v(dout1_27) AT=1010.05n

* CHECK dout1_28 Vdout1_28ck100 = 1.8 time = 1010
.meas tran vdout1_28ck100 FIND v(dout1_28) AT=1010.05n

* CHECK dout1_29 Vdout1_29ck100 = 0 time = 1010
.meas tran vdout1_29ck100 FIND v(dout1_29) AT=1010.05n

* CHECK dout1_30 Vdout1_30ck100 = 0 time = 1010
.meas tran vdout1_30ck100 FIND v(dout1_30) AT=1010.05n

* CHECK dout1_31 Vdout1_31ck100 = 0 time = 1010
.meas tran vdout1_31ck100 FIND v(dout1_31) AT=1010.05n

* CHECK dout0_0 Vdout0_0ck102 = 1.8 time = 1030
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=1030.05n

* CHECK dout0_1 Vdout0_1ck102 = 1.8 time = 1030
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=1030.05n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 1030
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=1030.05n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 1030
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=1030.05n

* CHECK dout0_4 Vdout0_4ck102 = 0 time = 1030
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=1030.05n

* CHECK dout0_5 Vdout0_5ck102 = 0 time = 1030
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=1030.05n

* CHECK dout0_6 Vdout0_6ck102 = 1.8 time = 1030
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=1030.05n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 1030
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=1030.05n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 1030
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=1030.05n

* CHECK dout0_9 Vdout0_9ck102 = 0 time = 1030
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=1030.05n

* CHECK dout0_10 Vdout0_10ck102 = 1.8 time = 1030
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=1030.05n

* CHECK dout0_11 Vdout0_11ck102 = 1.8 time = 1030
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=1030.05n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 1030
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=1030.05n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 1030
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=1030.05n

* CHECK dout0_14 Vdout0_14ck102 = 0 time = 1030
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=1030.05n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 1030
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=1030.05n

* CHECK dout0_16 Vdout0_16ck102 = 1.8 time = 1030
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=1030.05n

* CHECK dout0_17 Vdout0_17ck102 = 1.8 time = 1030
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=1030.05n

* CHECK dout0_18 Vdout0_18ck102 = 0 time = 1030
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=1030.05n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 1030
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=1030.05n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 1030
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=1030.05n

* CHECK dout0_21 Vdout0_21ck102 = 1.8 time = 1030
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=1030.05n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 1030
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=1030.05n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 1030
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=1030.05n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 1030
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=1030.05n

* CHECK dout0_25 Vdout0_25ck102 = 0 time = 1030
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=1030.05n

* CHECK dout0_26 Vdout0_26ck102 = 0 time = 1030
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=1030.05n

* CHECK dout0_27 Vdout0_27ck102 = 0 time = 1030
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=1030.05n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 1030
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=1030.05n

* CHECK dout0_29 Vdout0_29ck102 = 1.8 time = 1030
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=1030.05n

* CHECK dout0_30 Vdout0_30ck102 = 1.8 time = 1030
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=1030.05n

* CHECK dout0_31 Vdout0_31ck102 = 1.8 time = 1030
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=1030.05n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 0 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 1.8 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 1.8 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 1.8 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 0 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 1.8 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_8 Vdout0_8ck103 = 1.8 time = 1040
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=1040.05n

* CHECK dout0_9 Vdout0_9ck103 = 1.8 time = 1040
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=1040.05n

* CHECK dout0_10 Vdout0_10ck103 = 1.8 time = 1040
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=1040.05n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 1040
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=1040.05n

* CHECK dout0_12 Vdout0_12ck103 = 1.8 time = 1040
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=1040.05n

* CHECK dout0_13 Vdout0_13ck103 = 0 time = 1040
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=1040.05n

* CHECK dout0_14 Vdout0_14ck103 = 1.8 time = 1040
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=1040.05n

* CHECK dout0_15 Vdout0_15ck103 = 0 time = 1040
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=1040.05n

* CHECK dout0_16 Vdout0_16ck103 = 1.8 time = 1040
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=1040.05n

* CHECK dout0_17 Vdout0_17ck103 = 1.8 time = 1040
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=1040.05n

* CHECK dout0_18 Vdout0_18ck103 = 0 time = 1040
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=1040.05n

* CHECK dout0_19 Vdout0_19ck103 = 0 time = 1040
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=1040.05n

* CHECK dout0_20 Vdout0_20ck103 = 0 time = 1040
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=1040.05n

* CHECK dout0_21 Vdout0_21ck103 = 0 time = 1040
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=1040.05n

* CHECK dout0_22 Vdout0_22ck103 = 0 time = 1040
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=1040.05n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 1040
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=1040.05n

* CHECK dout0_24 Vdout0_24ck103 = 1.8 time = 1040
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=1040.05n

* CHECK dout0_25 Vdout0_25ck103 = 1.8 time = 1040
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=1040.05n

* CHECK dout0_26 Vdout0_26ck103 = 0 time = 1040
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=1040.05n

* CHECK dout0_27 Vdout0_27ck103 = 1.8 time = 1040
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=1040.05n

* CHECK dout0_28 Vdout0_28ck103 = 0 time = 1040
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=1040.05n

* CHECK dout0_29 Vdout0_29ck103 = 0 time = 1040
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=1040.05n

* CHECK dout0_30 Vdout0_30ck103 = 1.8 time = 1040
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=1040.05n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 1040
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=1040.05n

* CHECK dout1_0 Vdout1_0ck103 = 0 time = 1040
.meas tran vdout1_0ck103 FIND v(dout1_0) AT=1040.05n

* CHECK dout1_1 Vdout1_1ck103 = 1.8 time = 1040
.meas tran vdout1_1ck103 FIND v(dout1_1) AT=1040.05n

* CHECK dout1_2 Vdout1_2ck103 = 1.8 time = 1040
.meas tran vdout1_2ck103 FIND v(dout1_2) AT=1040.05n

* CHECK dout1_3 Vdout1_3ck103 = 1.8 time = 1040
.meas tran vdout1_3ck103 FIND v(dout1_3) AT=1040.05n

* CHECK dout1_4 Vdout1_4ck103 = 1.8 time = 1040
.meas tran vdout1_4ck103 FIND v(dout1_4) AT=1040.05n

* CHECK dout1_5 Vdout1_5ck103 = 0 time = 1040
.meas tran vdout1_5ck103 FIND v(dout1_5) AT=1040.05n

* CHECK dout1_6 Vdout1_6ck103 = 1.8 time = 1040
.meas tran vdout1_6ck103 FIND v(dout1_6) AT=1040.05n

* CHECK dout1_7 Vdout1_7ck103 = 0 time = 1040
.meas tran vdout1_7ck103 FIND v(dout1_7) AT=1040.05n

* CHECK dout1_8 Vdout1_8ck103 = 0 time = 1040
.meas tran vdout1_8ck103 FIND v(dout1_8) AT=1040.05n

* CHECK dout1_9 Vdout1_9ck103 = 1.8 time = 1040
.meas tran vdout1_9ck103 FIND v(dout1_9) AT=1040.05n

* CHECK dout1_10 Vdout1_10ck103 = 1.8 time = 1040
.meas tran vdout1_10ck103 FIND v(dout1_10) AT=1040.05n

* CHECK dout1_11 Vdout1_11ck103 = 0 time = 1040
.meas tran vdout1_11ck103 FIND v(dout1_11) AT=1040.05n

* CHECK dout1_12 Vdout1_12ck103 = 0 time = 1040
.meas tran vdout1_12ck103 FIND v(dout1_12) AT=1040.05n

* CHECK dout1_13 Vdout1_13ck103 = 1.8 time = 1040
.meas tran vdout1_13ck103 FIND v(dout1_13) AT=1040.05n

* CHECK dout1_14 Vdout1_14ck103 = 1.8 time = 1040
.meas tran vdout1_14ck103 FIND v(dout1_14) AT=1040.05n

* CHECK dout1_15 Vdout1_15ck103 = 0 time = 1040
.meas tran vdout1_15ck103 FIND v(dout1_15) AT=1040.05n

* CHECK dout1_16 Vdout1_16ck103 = 0 time = 1040
.meas tran vdout1_16ck103 FIND v(dout1_16) AT=1040.05n

* CHECK dout1_17 Vdout1_17ck103 = 0 time = 1040
.meas tran vdout1_17ck103 FIND v(dout1_17) AT=1040.05n

* CHECK dout1_18 Vdout1_18ck103 = 1.8 time = 1040
.meas tran vdout1_18ck103 FIND v(dout1_18) AT=1040.05n

* CHECK dout1_19 Vdout1_19ck103 = 1.8 time = 1040
.meas tran vdout1_19ck103 FIND v(dout1_19) AT=1040.05n

* CHECK dout1_20 Vdout1_20ck103 = 1.8 time = 1040
.meas tran vdout1_20ck103 FIND v(dout1_20) AT=1040.05n

* CHECK dout1_21 Vdout1_21ck103 = 1.8 time = 1040
.meas tran vdout1_21ck103 FIND v(dout1_21) AT=1040.05n

* CHECK dout1_22 Vdout1_22ck103 = 1.8 time = 1040
.meas tran vdout1_22ck103 FIND v(dout1_22) AT=1040.05n

* CHECK dout1_23 Vdout1_23ck103 = 1.8 time = 1040
.meas tran vdout1_23ck103 FIND v(dout1_23) AT=1040.05n

* CHECK dout1_24 Vdout1_24ck103 = 1.8 time = 1040
.meas tran vdout1_24ck103 FIND v(dout1_24) AT=1040.05n

* CHECK dout1_25 Vdout1_25ck103 = 0 time = 1040
.meas tran vdout1_25ck103 FIND v(dout1_25) AT=1040.05n

* CHECK dout1_26 Vdout1_26ck103 = 1.8 time = 1040
.meas tran vdout1_26ck103 FIND v(dout1_26) AT=1040.05n

* CHECK dout1_27 Vdout1_27ck103 = 0 time = 1040
.meas tran vdout1_27ck103 FIND v(dout1_27) AT=1040.05n

* CHECK dout1_28 Vdout1_28ck103 = 1.8 time = 1040
.meas tran vdout1_28ck103 FIND v(dout1_28) AT=1040.05n

* CHECK dout1_29 Vdout1_29ck103 = 1.8 time = 1040
.meas tran vdout1_29ck103 FIND v(dout1_29) AT=1040.05n

* CHECK dout1_30 Vdout1_30ck103 = 1.8 time = 1040
.meas tran vdout1_30ck103 FIND v(dout1_30) AT=1040.05n

* CHECK dout1_31 Vdout1_31ck103 = 0 time = 1040
.meas tran vdout1_31ck103 FIND v(dout1_31) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck104 = 1.8 time = 1050
.meas tran vdout0_0ck104 FIND v(dout0_0) AT=1050.05n

* CHECK dout0_1 Vdout0_1ck104 = 1.8 time = 1050
.meas tran vdout0_1ck104 FIND v(dout0_1) AT=1050.05n

* CHECK dout0_2 Vdout0_2ck104 = 1.8 time = 1050
.meas tran vdout0_2ck104 FIND v(dout0_2) AT=1050.05n

* CHECK dout0_3 Vdout0_3ck104 = 0 time = 1050
.meas tran vdout0_3ck104 FIND v(dout0_3) AT=1050.05n

* CHECK dout0_4 Vdout0_4ck104 = 0 time = 1050
.meas tran vdout0_4ck104 FIND v(dout0_4) AT=1050.05n

* CHECK dout0_5 Vdout0_5ck104 = 0 time = 1050
.meas tran vdout0_5ck104 FIND v(dout0_5) AT=1050.05n

* CHECK dout0_6 Vdout0_6ck104 = 0 time = 1050
.meas tran vdout0_6ck104 FIND v(dout0_6) AT=1050.05n

* CHECK dout0_7 Vdout0_7ck104 = 1.8 time = 1050
.meas tran vdout0_7ck104 FIND v(dout0_7) AT=1050.05n

* CHECK dout0_8 Vdout0_8ck104 = 0 time = 1050
.meas tran vdout0_8ck104 FIND v(dout0_8) AT=1050.05n

* CHECK dout0_9 Vdout0_9ck104 = 0 time = 1050
.meas tran vdout0_9ck104 FIND v(dout0_9) AT=1050.05n

* CHECK dout0_10 Vdout0_10ck104 = 0 time = 1050
.meas tran vdout0_10ck104 FIND v(dout0_10) AT=1050.05n

* CHECK dout0_11 Vdout0_11ck104 = 1.8 time = 1050
.meas tran vdout0_11ck104 FIND v(dout0_11) AT=1050.05n

* CHECK dout0_12 Vdout0_12ck104 = 0 time = 1050
.meas tran vdout0_12ck104 FIND v(dout0_12) AT=1050.05n

* CHECK dout0_13 Vdout0_13ck104 = 0 time = 1050
.meas tran vdout0_13ck104 FIND v(dout0_13) AT=1050.05n

* CHECK dout0_14 Vdout0_14ck104 = 0 time = 1050
.meas tran vdout0_14ck104 FIND v(dout0_14) AT=1050.05n

* CHECK dout0_15 Vdout0_15ck104 = 1.8 time = 1050
.meas tran vdout0_15ck104 FIND v(dout0_15) AT=1050.05n

* CHECK dout0_16 Vdout0_16ck104 = 1.8 time = 1050
.meas tran vdout0_16ck104 FIND v(dout0_16) AT=1050.05n

* CHECK dout0_17 Vdout0_17ck104 = 0 time = 1050
.meas tran vdout0_17ck104 FIND v(dout0_17) AT=1050.05n

* CHECK dout0_18 Vdout0_18ck104 = 1.8 time = 1050
.meas tran vdout0_18ck104 FIND v(dout0_18) AT=1050.05n

* CHECK dout0_19 Vdout0_19ck104 = 1.8 time = 1050
.meas tran vdout0_19ck104 FIND v(dout0_19) AT=1050.05n

* CHECK dout0_20 Vdout0_20ck104 = 0 time = 1050
.meas tran vdout0_20ck104 FIND v(dout0_20) AT=1050.05n

* CHECK dout0_21 Vdout0_21ck104 = 1.8 time = 1050
.meas tran vdout0_21ck104 FIND v(dout0_21) AT=1050.05n

* CHECK dout0_22 Vdout0_22ck104 = 0 time = 1050
.meas tran vdout0_22ck104 FIND v(dout0_22) AT=1050.05n

* CHECK dout0_23 Vdout0_23ck104 = 0 time = 1050
.meas tran vdout0_23ck104 FIND v(dout0_23) AT=1050.05n

* CHECK dout0_24 Vdout0_24ck104 = 1.8 time = 1050
.meas tran vdout0_24ck104 FIND v(dout0_24) AT=1050.05n

* CHECK dout0_25 Vdout0_25ck104 = 0 time = 1050
.meas tran vdout0_25ck104 FIND v(dout0_25) AT=1050.05n

* CHECK dout0_26 Vdout0_26ck104 = 1.8 time = 1050
.meas tran vdout0_26ck104 FIND v(dout0_26) AT=1050.05n

* CHECK dout0_27 Vdout0_27ck104 = 1.8 time = 1050
.meas tran vdout0_27ck104 FIND v(dout0_27) AT=1050.05n

* CHECK dout0_28 Vdout0_28ck104 = 1.8 time = 1050
.meas tran vdout0_28ck104 FIND v(dout0_28) AT=1050.05n

* CHECK dout0_29 Vdout0_29ck104 = 0 time = 1050
.meas tran vdout0_29ck104 FIND v(dout0_29) AT=1050.05n

* CHECK dout0_30 Vdout0_30ck104 = 0 time = 1050
.meas tran vdout0_30ck104 FIND v(dout0_30) AT=1050.05n

* CHECK dout0_31 Vdout0_31ck104 = 0 time = 1050
.meas tran vdout0_31ck104 FIND v(dout0_31) AT=1050.05n

* CHECK dout1_0 Vdout1_0ck106 = 1.8 time = 1070
.meas tran vdout1_0ck106 FIND v(dout1_0) AT=1070.05n

* CHECK dout1_1 Vdout1_1ck106 = 1.8 time = 1070
.meas tran vdout1_1ck106 FIND v(dout1_1) AT=1070.05n

* CHECK dout1_2 Vdout1_2ck106 = 1.8 time = 1070
.meas tran vdout1_2ck106 FIND v(dout1_2) AT=1070.05n

* CHECK dout1_3 Vdout1_3ck106 = 1.8 time = 1070
.meas tran vdout1_3ck106 FIND v(dout1_3) AT=1070.05n

* CHECK dout1_4 Vdout1_4ck106 = 0 time = 1070
.meas tran vdout1_4ck106 FIND v(dout1_4) AT=1070.05n

* CHECK dout1_5 Vdout1_5ck106 = 0 time = 1070
.meas tran vdout1_5ck106 FIND v(dout1_5) AT=1070.05n

* CHECK dout1_6 Vdout1_6ck106 = 1.8 time = 1070
.meas tran vdout1_6ck106 FIND v(dout1_6) AT=1070.05n

* CHECK dout1_7 Vdout1_7ck106 = 0 time = 1070
.meas tran vdout1_7ck106 FIND v(dout1_7) AT=1070.05n

* CHECK dout1_8 Vdout1_8ck106 = 0 time = 1070
.meas tran vdout1_8ck106 FIND v(dout1_8) AT=1070.05n

* CHECK dout1_9 Vdout1_9ck106 = 0 time = 1070
.meas tran vdout1_9ck106 FIND v(dout1_9) AT=1070.05n

* CHECK dout1_10 Vdout1_10ck106 = 1.8 time = 1070
.meas tran vdout1_10ck106 FIND v(dout1_10) AT=1070.05n

* CHECK dout1_11 Vdout1_11ck106 = 1.8 time = 1070
.meas tran vdout1_11ck106 FIND v(dout1_11) AT=1070.05n

* CHECK dout1_12 Vdout1_12ck106 = 1.8 time = 1070
.meas tran vdout1_12ck106 FIND v(dout1_12) AT=1070.05n

* CHECK dout1_13 Vdout1_13ck106 = 1.8 time = 1070
.meas tran vdout1_13ck106 FIND v(dout1_13) AT=1070.05n

* CHECK dout1_14 Vdout1_14ck106 = 0 time = 1070
.meas tran vdout1_14ck106 FIND v(dout1_14) AT=1070.05n

* CHECK dout1_15 Vdout1_15ck106 = 0 time = 1070
.meas tran vdout1_15ck106 FIND v(dout1_15) AT=1070.05n

* CHECK dout1_16 Vdout1_16ck106 = 1.8 time = 1070
.meas tran vdout1_16ck106 FIND v(dout1_16) AT=1070.05n

* CHECK dout1_17 Vdout1_17ck106 = 1.8 time = 1070
.meas tran vdout1_17ck106 FIND v(dout1_17) AT=1070.05n

* CHECK dout1_18 Vdout1_18ck106 = 0 time = 1070
.meas tran vdout1_18ck106 FIND v(dout1_18) AT=1070.05n

* CHECK dout1_19 Vdout1_19ck106 = 0 time = 1070
.meas tran vdout1_19ck106 FIND v(dout1_19) AT=1070.05n

* CHECK dout1_20 Vdout1_20ck106 = 0 time = 1070
.meas tran vdout1_20ck106 FIND v(dout1_20) AT=1070.05n

* CHECK dout1_21 Vdout1_21ck106 = 1.8 time = 1070
.meas tran vdout1_21ck106 FIND v(dout1_21) AT=1070.05n

* CHECK dout1_22 Vdout1_22ck106 = 0 time = 1070
.meas tran vdout1_22ck106 FIND v(dout1_22) AT=1070.05n

* CHECK dout1_23 Vdout1_23ck106 = 0 time = 1070
.meas tran vdout1_23ck106 FIND v(dout1_23) AT=1070.05n

* CHECK dout1_24 Vdout1_24ck106 = 1.8 time = 1070
.meas tran vdout1_24ck106 FIND v(dout1_24) AT=1070.05n

* CHECK dout1_25 Vdout1_25ck106 = 0 time = 1070
.meas tran vdout1_25ck106 FIND v(dout1_25) AT=1070.05n

* CHECK dout1_26 Vdout1_26ck106 = 0 time = 1070
.meas tran vdout1_26ck106 FIND v(dout1_26) AT=1070.05n

* CHECK dout1_27 Vdout1_27ck106 = 0 time = 1070
.meas tran vdout1_27ck106 FIND v(dout1_27) AT=1070.05n

* CHECK dout1_28 Vdout1_28ck106 = 0 time = 1070
.meas tran vdout1_28ck106 FIND v(dout1_28) AT=1070.05n

* CHECK dout1_29 Vdout1_29ck106 = 1.8 time = 1070
.meas tran vdout1_29ck106 FIND v(dout1_29) AT=1070.05n

* CHECK dout1_30 Vdout1_30ck106 = 1.8 time = 1070
.meas tran vdout1_30ck106 FIND v(dout1_30) AT=1070.05n

* CHECK dout1_31 Vdout1_31ck106 = 1.8 time = 1070
.meas tran vdout1_31ck106 FIND v(dout1_31) AT=1070.05n

* CHECK dout1_0 Vdout1_0ck107 = 0 time = 1080
.meas tran vdout1_0ck107 FIND v(dout1_0) AT=1080.05n

* CHECK dout1_1 Vdout1_1ck107 = 1.8 time = 1080
.meas tran vdout1_1ck107 FIND v(dout1_1) AT=1080.05n

* CHECK dout1_2 Vdout1_2ck107 = 1.8 time = 1080
.meas tran vdout1_2ck107 FIND v(dout1_2) AT=1080.05n

* CHECK dout1_3 Vdout1_3ck107 = 1.8 time = 1080
.meas tran vdout1_3ck107 FIND v(dout1_3) AT=1080.05n

* CHECK dout1_4 Vdout1_4ck107 = 1.8 time = 1080
.meas tran vdout1_4ck107 FIND v(dout1_4) AT=1080.05n

* CHECK dout1_5 Vdout1_5ck107 = 0 time = 1080
.meas tran vdout1_5ck107 FIND v(dout1_5) AT=1080.05n

* CHECK dout1_6 Vdout1_6ck107 = 1.8 time = 1080
.meas tran vdout1_6ck107 FIND v(dout1_6) AT=1080.05n

* CHECK dout1_7 Vdout1_7ck107 = 0 time = 1080
.meas tran vdout1_7ck107 FIND v(dout1_7) AT=1080.05n

* CHECK dout1_8 Vdout1_8ck107 = 0 time = 1080
.meas tran vdout1_8ck107 FIND v(dout1_8) AT=1080.05n

* CHECK dout1_9 Vdout1_9ck107 = 1.8 time = 1080
.meas tran vdout1_9ck107 FIND v(dout1_9) AT=1080.05n

* CHECK dout1_10 Vdout1_10ck107 = 1.8 time = 1080
.meas tran vdout1_10ck107 FIND v(dout1_10) AT=1080.05n

* CHECK dout1_11 Vdout1_11ck107 = 0 time = 1080
.meas tran vdout1_11ck107 FIND v(dout1_11) AT=1080.05n

* CHECK dout1_12 Vdout1_12ck107 = 0 time = 1080
.meas tran vdout1_12ck107 FIND v(dout1_12) AT=1080.05n

* CHECK dout1_13 Vdout1_13ck107 = 1.8 time = 1080
.meas tran vdout1_13ck107 FIND v(dout1_13) AT=1080.05n

* CHECK dout1_14 Vdout1_14ck107 = 1.8 time = 1080
.meas tran vdout1_14ck107 FIND v(dout1_14) AT=1080.05n

* CHECK dout1_15 Vdout1_15ck107 = 0 time = 1080
.meas tran vdout1_15ck107 FIND v(dout1_15) AT=1080.05n

* CHECK dout1_16 Vdout1_16ck107 = 0 time = 1080
.meas tran vdout1_16ck107 FIND v(dout1_16) AT=1080.05n

* CHECK dout1_17 Vdout1_17ck107 = 0 time = 1080
.meas tran vdout1_17ck107 FIND v(dout1_17) AT=1080.05n

* CHECK dout1_18 Vdout1_18ck107 = 1.8 time = 1080
.meas tran vdout1_18ck107 FIND v(dout1_18) AT=1080.05n

* CHECK dout1_19 Vdout1_19ck107 = 1.8 time = 1080
.meas tran vdout1_19ck107 FIND v(dout1_19) AT=1080.05n

* CHECK dout1_20 Vdout1_20ck107 = 1.8 time = 1080
.meas tran vdout1_20ck107 FIND v(dout1_20) AT=1080.05n

* CHECK dout1_21 Vdout1_21ck107 = 1.8 time = 1080
.meas tran vdout1_21ck107 FIND v(dout1_21) AT=1080.05n

* CHECK dout1_22 Vdout1_22ck107 = 1.8 time = 1080
.meas tran vdout1_22ck107 FIND v(dout1_22) AT=1080.05n

* CHECK dout1_23 Vdout1_23ck107 = 1.8 time = 1080
.meas tran vdout1_23ck107 FIND v(dout1_23) AT=1080.05n

* CHECK dout1_24 Vdout1_24ck107 = 1.8 time = 1080
.meas tran vdout1_24ck107 FIND v(dout1_24) AT=1080.05n

* CHECK dout1_25 Vdout1_25ck107 = 0 time = 1080
.meas tran vdout1_25ck107 FIND v(dout1_25) AT=1080.05n

* CHECK dout1_26 Vdout1_26ck107 = 1.8 time = 1080
.meas tran vdout1_26ck107 FIND v(dout1_26) AT=1080.05n

* CHECK dout1_27 Vdout1_27ck107 = 0 time = 1080
.meas tran vdout1_27ck107 FIND v(dout1_27) AT=1080.05n

* CHECK dout1_28 Vdout1_28ck107 = 1.8 time = 1080
.meas tran vdout1_28ck107 FIND v(dout1_28) AT=1080.05n

* CHECK dout1_29 Vdout1_29ck107 = 1.8 time = 1080
.meas tran vdout1_29ck107 FIND v(dout1_29) AT=1080.05n

* CHECK dout1_30 Vdout1_30ck107 = 1.8 time = 1080
.meas tran vdout1_30ck107 FIND v(dout1_30) AT=1080.05n

* CHECK dout1_31 Vdout1_31ck107 = 0 time = 1080
.meas tran vdout1_31ck107 FIND v(dout1_31) AT=1080.05n

* CHECK dout1_0 Vdout1_0ck109 = 1.8 time = 1100
.meas tran vdout1_0ck109 FIND v(dout1_0) AT=1100.05n

* CHECK dout1_1 Vdout1_1ck109 = 1.8 time = 1100
.meas tran vdout1_1ck109 FIND v(dout1_1) AT=1100.05n

* CHECK dout1_2 Vdout1_2ck109 = 1.8 time = 1100
.meas tran vdout1_2ck109 FIND v(dout1_2) AT=1100.05n

* CHECK dout1_3 Vdout1_3ck109 = 0 time = 1100
.meas tran vdout1_3ck109 FIND v(dout1_3) AT=1100.05n

* CHECK dout1_4 Vdout1_4ck109 = 0 time = 1100
.meas tran vdout1_4ck109 FIND v(dout1_4) AT=1100.05n

* CHECK dout1_5 Vdout1_5ck109 = 0 time = 1100
.meas tran vdout1_5ck109 FIND v(dout1_5) AT=1100.05n

* CHECK dout1_6 Vdout1_6ck109 = 0 time = 1100
.meas tran vdout1_6ck109 FIND v(dout1_6) AT=1100.05n

* CHECK dout1_7 Vdout1_7ck109 = 1.8 time = 1100
.meas tran vdout1_7ck109 FIND v(dout1_7) AT=1100.05n

* CHECK dout1_8 Vdout1_8ck109 = 1.8 time = 1100
.meas tran vdout1_8ck109 FIND v(dout1_8) AT=1100.05n

* CHECK dout1_9 Vdout1_9ck109 = 0 time = 1100
.meas tran vdout1_9ck109 FIND v(dout1_9) AT=1100.05n

* CHECK dout1_10 Vdout1_10ck109 = 1.8 time = 1100
.meas tran vdout1_10ck109 FIND v(dout1_10) AT=1100.05n

* CHECK dout1_11 Vdout1_11ck109 = 1.8 time = 1100
.meas tran vdout1_11ck109 FIND v(dout1_11) AT=1100.05n

* CHECK dout1_12 Vdout1_12ck109 = 1.8 time = 1100
.meas tran vdout1_12ck109 FIND v(dout1_12) AT=1100.05n

* CHECK dout1_13 Vdout1_13ck109 = 1.8 time = 1100
.meas tran vdout1_13ck109 FIND v(dout1_13) AT=1100.05n

* CHECK dout1_14 Vdout1_14ck109 = 1.8 time = 1100
.meas tran vdout1_14ck109 FIND v(dout1_14) AT=1100.05n

* CHECK dout1_15 Vdout1_15ck109 = 0 time = 1100
.meas tran vdout1_15ck109 FIND v(dout1_15) AT=1100.05n

* CHECK dout1_16 Vdout1_16ck109 = 1.8 time = 1100
.meas tran vdout1_16ck109 FIND v(dout1_16) AT=1100.05n

* CHECK dout1_17 Vdout1_17ck109 = 1.8 time = 1100
.meas tran vdout1_17ck109 FIND v(dout1_17) AT=1100.05n

* CHECK dout1_18 Vdout1_18ck109 = 1.8 time = 1100
.meas tran vdout1_18ck109 FIND v(dout1_18) AT=1100.05n

* CHECK dout1_19 Vdout1_19ck109 = 1.8 time = 1100
.meas tran vdout1_19ck109 FIND v(dout1_19) AT=1100.05n

* CHECK dout1_20 Vdout1_20ck109 = 0 time = 1100
.meas tran vdout1_20ck109 FIND v(dout1_20) AT=1100.05n

* CHECK dout1_21 Vdout1_21ck109 = 1.8 time = 1100
.meas tran vdout1_21ck109 FIND v(dout1_21) AT=1100.05n

* CHECK dout1_22 Vdout1_22ck109 = 0 time = 1100
.meas tran vdout1_22ck109 FIND v(dout1_22) AT=1100.05n

* CHECK dout1_23 Vdout1_23ck109 = 0 time = 1100
.meas tran vdout1_23ck109 FIND v(dout1_23) AT=1100.05n

* CHECK dout1_24 Vdout1_24ck109 = 1.8 time = 1100
.meas tran vdout1_24ck109 FIND v(dout1_24) AT=1100.05n

* CHECK dout1_25 Vdout1_25ck109 = 0 time = 1100
.meas tran vdout1_25ck109 FIND v(dout1_25) AT=1100.05n

* CHECK dout1_26 Vdout1_26ck109 = 1.8 time = 1100
.meas tran vdout1_26ck109 FIND v(dout1_26) AT=1100.05n

* CHECK dout1_27 Vdout1_27ck109 = 1.8 time = 1100
.meas tran vdout1_27ck109 FIND v(dout1_27) AT=1100.05n

* CHECK dout1_28 Vdout1_28ck109 = 1.8 time = 1100
.meas tran vdout1_28ck109 FIND v(dout1_28) AT=1100.05n

* CHECK dout1_29 Vdout1_29ck109 = 0 time = 1100
.meas tran vdout1_29ck109 FIND v(dout1_29) AT=1100.05n

* CHECK dout1_30 Vdout1_30ck109 = 0 time = 1100
.meas tran vdout1_30ck109 FIND v(dout1_30) AT=1100.05n

* CHECK dout1_31 Vdout1_31ck109 = 0 time = 1100
.meas tran vdout1_31ck109 FIND v(dout1_31) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 1120
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=1120.05n

* CHECK dout0_1 Vdout0_1ck111 = 0 time = 1120
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=1120.05n

* CHECK dout0_2 Vdout0_2ck111 = 1.8 time = 1120
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=1120.05n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 1120
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=1120.05n

* CHECK dout0_4 Vdout0_4ck111 = 1.8 time = 1120
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=1120.05n

* CHECK dout0_5 Vdout0_5ck111 = 1.8 time = 1120
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=1120.05n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 1120
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=1120.05n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 1120
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=1120.05n

* CHECK dout0_8 Vdout0_8ck111 = 0 time = 1120
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=1120.05n

* CHECK dout0_9 Vdout0_9ck111 = 0 time = 1120
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=1120.05n

* CHECK dout0_10 Vdout0_10ck111 = 0 time = 1120
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=1120.05n

* CHECK dout0_11 Vdout0_11ck111 = 1.8 time = 1120
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=1120.05n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 1120
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=1120.05n

* CHECK dout0_13 Vdout0_13ck111 = 0 time = 1120
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=1120.05n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 1120
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=1120.05n

* CHECK dout0_15 Vdout0_15ck111 = 1.8 time = 1120
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=1120.05n

* CHECK dout0_16 Vdout0_16ck111 = 0 time = 1120
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=1120.05n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 1120
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=1120.05n

* CHECK dout0_18 Vdout0_18ck111 = 0 time = 1120
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=1120.05n

* CHECK dout0_19 Vdout0_19ck111 = 0 time = 1120
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=1120.05n

* CHECK dout0_20 Vdout0_20ck111 = 1.8 time = 1120
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=1120.05n

* CHECK dout0_21 Vdout0_21ck111 = 1.8 time = 1120
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=1120.05n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 1120
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=1120.05n

* CHECK dout0_23 Vdout0_23ck111 = 0 time = 1120
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=1120.05n

* CHECK dout0_24 Vdout0_24ck111 = 0 time = 1120
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=1120.05n

* CHECK dout0_25 Vdout0_25ck111 = 1.8 time = 1120
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=1120.05n

* CHECK dout0_26 Vdout0_26ck111 = 0 time = 1120
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=1120.05n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 1120
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=1120.05n

* CHECK dout0_28 Vdout0_28ck111 = 1.8 time = 1120
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=1120.05n

* CHECK dout0_29 Vdout0_29ck111 = 1.8 time = 1120
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=1120.05n

* CHECK dout0_30 Vdout0_30ck111 = 0 time = 1120
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=1120.05n

* CHECK dout0_31 Vdout0_31ck111 = 0 time = 1120
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=1120.05n

* CHECK dout0_0 Vdout0_0ck112 = 1.8 time = 1130
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=1130.05n

* CHECK dout0_1 Vdout0_1ck112 = 1.8 time = 1130
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=1130.05n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 1130
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=1130.05n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 1130
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=1130.05n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 1130
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=1130.05n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 1130
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=1130.05n

* CHECK dout0_6 Vdout0_6ck112 = 0 time = 1130
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=1130.05n

* CHECK dout0_7 Vdout0_7ck112 = 1.8 time = 1130
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=1130.05n

* CHECK dout0_8 Vdout0_8ck112 = 1.8 time = 1130
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=1130.05n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 1130
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=1130.05n

* CHECK dout0_10 Vdout0_10ck112 = 1.8 time = 1130
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=1130.05n

* CHECK dout0_11 Vdout0_11ck112 = 1.8 time = 1130
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=1130.05n

* CHECK dout0_12 Vdout0_12ck112 = 1.8 time = 1130
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=1130.05n

* CHECK dout0_13 Vdout0_13ck112 = 1.8 time = 1130
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=1130.05n

* CHECK dout0_14 Vdout0_14ck112 = 1.8 time = 1130
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=1130.05n

* CHECK dout0_15 Vdout0_15ck112 = 0 time = 1130
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=1130.05n

* CHECK dout0_16 Vdout0_16ck112 = 1.8 time = 1130
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=1130.05n

* CHECK dout0_17 Vdout0_17ck112 = 1.8 time = 1130
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=1130.05n

* CHECK dout0_18 Vdout0_18ck112 = 1.8 time = 1130
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=1130.05n

* CHECK dout0_19 Vdout0_19ck112 = 1.8 time = 1130
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=1130.05n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 1130
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=1130.05n

* CHECK dout0_21 Vdout0_21ck112 = 1.8 time = 1130
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=1130.05n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 1130
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=1130.05n

* CHECK dout0_23 Vdout0_23ck112 = 0 time = 1130
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=1130.05n

* CHECK dout0_24 Vdout0_24ck112 = 1.8 time = 1130
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=1130.05n

* CHECK dout0_25 Vdout0_25ck112 = 0 time = 1130
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=1130.05n

* CHECK dout0_26 Vdout0_26ck112 = 1.8 time = 1130
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=1130.05n

* CHECK dout0_27 Vdout0_27ck112 = 1.8 time = 1130
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=1130.05n

* CHECK dout0_28 Vdout0_28ck112 = 1.8 time = 1130
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=1130.05n

* CHECK dout0_29 Vdout0_29ck112 = 0 time = 1130
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=1130.05n

* CHECK dout0_30 Vdout0_30ck112 = 0 time = 1130
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=1130.05n

* CHECK dout0_31 Vdout0_31ck112 = 0 time = 1130
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=1130.05n

* CHECK dout1_0 Vdout1_0ck112 = 0 time = 1130
.meas tran vdout1_0ck112 FIND v(dout1_0) AT=1130.05n

* CHECK dout1_1 Vdout1_1ck112 = 0 time = 1130
.meas tran vdout1_1ck112 FIND v(dout1_1) AT=1130.05n

* CHECK dout1_2 Vdout1_2ck112 = 0 time = 1130
.meas tran vdout1_2ck112 FIND v(dout1_2) AT=1130.05n

* CHECK dout1_3 Vdout1_3ck112 = 0 time = 1130
.meas tran vdout1_3ck112 FIND v(dout1_3) AT=1130.05n

* CHECK dout1_4 Vdout1_4ck112 = 0 time = 1130
.meas tran vdout1_4ck112 FIND v(dout1_4) AT=1130.05n

* CHECK dout1_5 Vdout1_5ck112 = 1.8 time = 1130
.meas tran vdout1_5ck112 FIND v(dout1_5) AT=1130.05n

* CHECK dout1_6 Vdout1_6ck112 = 0 time = 1130
.meas tran vdout1_6ck112 FIND v(dout1_6) AT=1130.05n

* CHECK dout1_7 Vdout1_7ck112 = 1.8 time = 1130
.meas tran vdout1_7ck112 FIND v(dout1_7) AT=1130.05n

* CHECK dout1_8 Vdout1_8ck112 = 0 time = 1130
.meas tran vdout1_8ck112 FIND v(dout1_8) AT=1130.05n

* CHECK dout1_9 Vdout1_9ck112 = 0 time = 1130
.meas tran vdout1_9ck112 FIND v(dout1_9) AT=1130.05n

* CHECK dout1_10 Vdout1_10ck112 = 1.8 time = 1130
.meas tran vdout1_10ck112 FIND v(dout1_10) AT=1130.05n

* CHECK dout1_11 Vdout1_11ck112 = 0 time = 1130
.meas tran vdout1_11ck112 FIND v(dout1_11) AT=1130.05n

* CHECK dout1_12 Vdout1_12ck112 = 1.8 time = 1130
.meas tran vdout1_12ck112 FIND v(dout1_12) AT=1130.05n

* CHECK dout1_13 Vdout1_13ck112 = 0 time = 1130
.meas tran vdout1_13ck112 FIND v(dout1_13) AT=1130.05n

* CHECK dout1_14 Vdout1_14ck112 = 1.8 time = 1130
.meas tran vdout1_14ck112 FIND v(dout1_14) AT=1130.05n

* CHECK dout1_15 Vdout1_15ck112 = 0 time = 1130
.meas tran vdout1_15ck112 FIND v(dout1_15) AT=1130.05n

* CHECK dout1_16 Vdout1_16ck112 = 0 time = 1130
.meas tran vdout1_16ck112 FIND v(dout1_16) AT=1130.05n

* CHECK dout1_17 Vdout1_17ck112 = 0 time = 1130
.meas tran vdout1_17ck112 FIND v(dout1_17) AT=1130.05n

* CHECK dout1_18 Vdout1_18ck112 = 1.8 time = 1130
.meas tran vdout1_18ck112 FIND v(dout1_18) AT=1130.05n

* CHECK dout1_19 Vdout1_19ck112 = 0 time = 1130
.meas tran vdout1_19ck112 FIND v(dout1_19) AT=1130.05n

* CHECK dout1_20 Vdout1_20ck112 = 0 time = 1130
.meas tran vdout1_20ck112 FIND v(dout1_20) AT=1130.05n

* CHECK dout1_21 Vdout1_21ck112 = 0 time = 1130
.meas tran vdout1_21ck112 FIND v(dout1_21) AT=1130.05n

* CHECK dout1_22 Vdout1_22ck112 = 0 time = 1130
.meas tran vdout1_22ck112 FIND v(dout1_22) AT=1130.05n

* CHECK dout1_23 Vdout1_23ck112 = 1.8 time = 1130
.meas tran vdout1_23ck112 FIND v(dout1_23) AT=1130.05n

* CHECK dout1_24 Vdout1_24ck112 = 0 time = 1130
.meas tran vdout1_24ck112 FIND v(dout1_24) AT=1130.05n

* CHECK dout1_25 Vdout1_25ck112 = 1.8 time = 1130
.meas tran vdout1_25ck112 FIND v(dout1_25) AT=1130.05n

* CHECK dout1_26 Vdout1_26ck112 = 0 time = 1130
.meas tran vdout1_26ck112 FIND v(dout1_26) AT=1130.05n

* CHECK dout1_27 Vdout1_27ck112 = 0 time = 1130
.meas tran vdout1_27ck112 FIND v(dout1_27) AT=1130.05n

* CHECK dout1_28 Vdout1_28ck112 = 0 time = 1130
.meas tran vdout1_28ck112 FIND v(dout1_28) AT=1130.05n

* CHECK dout1_29 Vdout1_29ck112 = 0 time = 1130
.meas tran vdout1_29ck112 FIND v(dout1_29) AT=1130.05n

* CHECK dout1_30 Vdout1_30ck112 = 0 time = 1130
.meas tran vdout1_30ck112 FIND v(dout1_30) AT=1130.05n

* CHECK dout1_31 Vdout1_31ck112 = 0 time = 1130
.meas tran vdout1_31ck112 FIND v(dout1_31) AT=1130.05n

* CHECK dout0_0 Vdout0_0ck114 = 0 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 1.8 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 1.8 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 1.8 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 1.8 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 0 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_8 Vdout0_8ck114 = 0 time = 1150
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=1150.05n

* CHECK dout0_9 Vdout0_9ck114 = 1.8 time = 1150
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=1150.05n

* CHECK dout0_10 Vdout0_10ck114 = 1.8 time = 1150
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=1150.05n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 1150
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=1150.05n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 1150
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=1150.05n

* CHECK dout0_13 Vdout0_13ck114 = 1.8 time = 1150
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=1150.05n

* CHECK dout0_14 Vdout0_14ck114 = 0 time = 1150
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=1150.05n

* CHECK dout0_15 Vdout0_15ck114 = 1.8 time = 1150
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=1150.05n

* CHECK dout0_16 Vdout0_16ck114 = 1.8 time = 1150
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=1150.05n

* CHECK dout0_17 Vdout0_17ck114 = 1.8 time = 1150
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=1150.05n

* CHECK dout0_18 Vdout0_18ck114 = 1.8 time = 1150
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=1150.05n

* CHECK dout0_19 Vdout0_19ck114 = 1.8 time = 1150
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=1150.05n

* CHECK dout0_20 Vdout0_20ck114 = 0 time = 1150
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=1150.05n

* CHECK dout0_21 Vdout0_21ck114 = 1.8 time = 1150
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=1150.05n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 1150
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=1150.05n

* CHECK dout0_23 Vdout0_23ck114 = 1.8 time = 1150
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=1150.05n

* CHECK dout0_24 Vdout0_24ck114 = 1.8 time = 1150
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=1150.05n

* CHECK dout0_25 Vdout0_25ck114 = 1.8 time = 1150
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=1150.05n

* CHECK dout0_26 Vdout0_26ck114 = 1.8 time = 1150
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=1150.05n

* CHECK dout0_27 Vdout0_27ck114 = 0 time = 1150
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=1150.05n

* CHECK dout0_28 Vdout0_28ck114 = 1.8 time = 1150
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=1150.05n

* CHECK dout0_29 Vdout0_29ck114 = 0 time = 1150
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=1150.05n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 1150
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=1150.05n

* CHECK dout0_31 Vdout0_31ck114 = 1.8 time = 1150
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=1150.05n

* CHECK dout1_0 Vdout1_0ck114 = 1.8 time = 1150
.meas tran vdout1_0ck114 FIND v(dout1_0) AT=1150.05n

* CHECK dout1_1 Vdout1_1ck114 = 1.8 time = 1150
.meas tran vdout1_1ck114 FIND v(dout1_1) AT=1150.05n

* CHECK dout1_2 Vdout1_2ck114 = 1.8 time = 1150
.meas tran vdout1_2ck114 FIND v(dout1_2) AT=1150.05n

* CHECK dout1_3 Vdout1_3ck114 = 0 time = 1150
.meas tran vdout1_3ck114 FIND v(dout1_3) AT=1150.05n

* CHECK dout1_4 Vdout1_4ck114 = 0 time = 1150
.meas tran vdout1_4ck114 FIND v(dout1_4) AT=1150.05n

* CHECK dout1_5 Vdout1_5ck114 = 0 time = 1150
.meas tran vdout1_5ck114 FIND v(dout1_5) AT=1150.05n

* CHECK dout1_6 Vdout1_6ck114 = 0 time = 1150
.meas tran vdout1_6ck114 FIND v(dout1_6) AT=1150.05n

* CHECK dout1_7 Vdout1_7ck114 = 1.8 time = 1150
.meas tran vdout1_7ck114 FIND v(dout1_7) AT=1150.05n

* CHECK dout1_8 Vdout1_8ck114 = 1.8 time = 1150
.meas tran vdout1_8ck114 FIND v(dout1_8) AT=1150.05n

* CHECK dout1_9 Vdout1_9ck114 = 0 time = 1150
.meas tran vdout1_9ck114 FIND v(dout1_9) AT=1150.05n

* CHECK dout1_10 Vdout1_10ck114 = 1.8 time = 1150
.meas tran vdout1_10ck114 FIND v(dout1_10) AT=1150.05n

* CHECK dout1_11 Vdout1_11ck114 = 1.8 time = 1150
.meas tran vdout1_11ck114 FIND v(dout1_11) AT=1150.05n

* CHECK dout1_12 Vdout1_12ck114 = 1.8 time = 1150
.meas tran vdout1_12ck114 FIND v(dout1_12) AT=1150.05n

* CHECK dout1_13 Vdout1_13ck114 = 1.8 time = 1150
.meas tran vdout1_13ck114 FIND v(dout1_13) AT=1150.05n

* CHECK dout1_14 Vdout1_14ck114 = 1.8 time = 1150
.meas tran vdout1_14ck114 FIND v(dout1_14) AT=1150.05n

* CHECK dout1_15 Vdout1_15ck114 = 0 time = 1150
.meas tran vdout1_15ck114 FIND v(dout1_15) AT=1150.05n

* CHECK dout1_16 Vdout1_16ck114 = 1.8 time = 1150
.meas tran vdout1_16ck114 FIND v(dout1_16) AT=1150.05n

* CHECK dout1_17 Vdout1_17ck114 = 1.8 time = 1150
.meas tran vdout1_17ck114 FIND v(dout1_17) AT=1150.05n

* CHECK dout1_18 Vdout1_18ck114 = 1.8 time = 1150
.meas tran vdout1_18ck114 FIND v(dout1_18) AT=1150.05n

* CHECK dout1_19 Vdout1_19ck114 = 1.8 time = 1150
.meas tran vdout1_19ck114 FIND v(dout1_19) AT=1150.05n

* CHECK dout1_20 Vdout1_20ck114 = 0 time = 1150
.meas tran vdout1_20ck114 FIND v(dout1_20) AT=1150.05n

* CHECK dout1_21 Vdout1_21ck114 = 1.8 time = 1150
.meas tran vdout1_21ck114 FIND v(dout1_21) AT=1150.05n

* CHECK dout1_22 Vdout1_22ck114 = 0 time = 1150
.meas tran vdout1_22ck114 FIND v(dout1_22) AT=1150.05n

* CHECK dout1_23 Vdout1_23ck114 = 0 time = 1150
.meas tran vdout1_23ck114 FIND v(dout1_23) AT=1150.05n

* CHECK dout1_24 Vdout1_24ck114 = 1.8 time = 1150
.meas tran vdout1_24ck114 FIND v(dout1_24) AT=1150.05n

* CHECK dout1_25 Vdout1_25ck114 = 0 time = 1150
.meas tran vdout1_25ck114 FIND v(dout1_25) AT=1150.05n

* CHECK dout1_26 Vdout1_26ck114 = 1.8 time = 1150
.meas tran vdout1_26ck114 FIND v(dout1_26) AT=1150.05n

* CHECK dout1_27 Vdout1_27ck114 = 1.8 time = 1150
.meas tran vdout1_27ck114 FIND v(dout1_27) AT=1150.05n

* CHECK dout1_28 Vdout1_28ck114 = 1.8 time = 1150
.meas tran vdout1_28ck114 FIND v(dout1_28) AT=1150.05n

* CHECK dout1_29 Vdout1_29ck114 = 0 time = 1150
.meas tran vdout1_29ck114 FIND v(dout1_29) AT=1150.05n

* CHECK dout1_30 Vdout1_30ck114 = 0 time = 1150
.meas tran vdout1_30ck114 FIND v(dout1_30) AT=1150.05n

* CHECK dout1_31 Vdout1_31ck114 = 0 time = 1150
.meas tran vdout1_31ck114 FIND v(dout1_31) AT=1150.05n

* CHECK dout1_0 Vdout1_0ck115 = 0 time = 1160
.meas tran vdout1_0ck115 FIND v(dout1_0) AT=1160.05n

* CHECK dout1_1 Vdout1_1ck115 = 0 time = 1160
.meas tran vdout1_1ck115 FIND v(dout1_1) AT=1160.05n

* CHECK dout1_2 Vdout1_2ck115 = 1.8 time = 1160
.meas tran vdout1_2ck115 FIND v(dout1_2) AT=1160.05n

* CHECK dout1_3 Vdout1_3ck115 = 0 time = 1160
.meas tran vdout1_3ck115 FIND v(dout1_3) AT=1160.05n

* CHECK dout1_4 Vdout1_4ck115 = 1.8 time = 1160
.meas tran vdout1_4ck115 FIND v(dout1_4) AT=1160.05n

* CHECK dout1_5 Vdout1_5ck115 = 1.8 time = 1160
.meas tran vdout1_5ck115 FIND v(dout1_5) AT=1160.05n

* CHECK dout1_6 Vdout1_6ck115 = 0 time = 1160
.meas tran vdout1_6ck115 FIND v(dout1_6) AT=1160.05n

* CHECK dout1_7 Vdout1_7ck115 = 0 time = 1160
.meas tran vdout1_7ck115 FIND v(dout1_7) AT=1160.05n

* CHECK dout1_8 Vdout1_8ck115 = 0 time = 1160
.meas tran vdout1_8ck115 FIND v(dout1_8) AT=1160.05n

* CHECK dout1_9 Vdout1_9ck115 = 0 time = 1160
.meas tran vdout1_9ck115 FIND v(dout1_9) AT=1160.05n

* CHECK dout1_10 Vdout1_10ck115 = 0 time = 1160
.meas tran vdout1_10ck115 FIND v(dout1_10) AT=1160.05n

* CHECK dout1_11 Vdout1_11ck115 = 1.8 time = 1160
.meas tran vdout1_11ck115 FIND v(dout1_11) AT=1160.05n

* CHECK dout1_12 Vdout1_12ck115 = 0 time = 1160
.meas tran vdout1_12ck115 FIND v(dout1_12) AT=1160.05n

* CHECK dout1_13 Vdout1_13ck115 = 0 time = 1160
.meas tran vdout1_13ck115 FIND v(dout1_13) AT=1160.05n

* CHECK dout1_14 Vdout1_14ck115 = 0 time = 1160
.meas tran vdout1_14ck115 FIND v(dout1_14) AT=1160.05n

* CHECK dout1_15 Vdout1_15ck115 = 1.8 time = 1160
.meas tran vdout1_15ck115 FIND v(dout1_15) AT=1160.05n

* CHECK dout1_16 Vdout1_16ck115 = 0 time = 1160
.meas tran vdout1_16ck115 FIND v(dout1_16) AT=1160.05n

* CHECK dout1_17 Vdout1_17ck115 = 0 time = 1160
.meas tran vdout1_17ck115 FIND v(dout1_17) AT=1160.05n

* CHECK dout1_18 Vdout1_18ck115 = 0 time = 1160
.meas tran vdout1_18ck115 FIND v(dout1_18) AT=1160.05n

* CHECK dout1_19 Vdout1_19ck115 = 0 time = 1160
.meas tran vdout1_19ck115 FIND v(dout1_19) AT=1160.05n

* CHECK dout1_20 Vdout1_20ck115 = 1.8 time = 1160
.meas tran vdout1_20ck115 FIND v(dout1_20) AT=1160.05n

* CHECK dout1_21 Vdout1_21ck115 = 1.8 time = 1160
.meas tran vdout1_21ck115 FIND v(dout1_21) AT=1160.05n

* CHECK dout1_22 Vdout1_22ck115 = 0 time = 1160
.meas tran vdout1_22ck115 FIND v(dout1_22) AT=1160.05n

* CHECK dout1_23 Vdout1_23ck115 = 0 time = 1160
.meas tran vdout1_23ck115 FIND v(dout1_23) AT=1160.05n

* CHECK dout1_24 Vdout1_24ck115 = 0 time = 1160
.meas tran vdout1_24ck115 FIND v(dout1_24) AT=1160.05n

* CHECK dout1_25 Vdout1_25ck115 = 1.8 time = 1160
.meas tran vdout1_25ck115 FIND v(dout1_25) AT=1160.05n

* CHECK dout1_26 Vdout1_26ck115 = 0 time = 1160
.meas tran vdout1_26ck115 FIND v(dout1_26) AT=1160.05n

* CHECK dout1_27 Vdout1_27ck115 = 0 time = 1160
.meas tran vdout1_27ck115 FIND v(dout1_27) AT=1160.05n

* CHECK dout1_28 Vdout1_28ck115 = 1.8 time = 1160
.meas tran vdout1_28ck115 FIND v(dout1_28) AT=1160.05n

* CHECK dout1_29 Vdout1_29ck115 = 1.8 time = 1160
.meas tran vdout1_29ck115 FIND v(dout1_29) AT=1160.05n

* CHECK dout1_30 Vdout1_30ck115 = 0 time = 1160
.meas tran vdout1_30ck115 FIND v(dout1_30) AT=1160.05n

* CHECK dout1_31 Vdout1_31ck115 = 0 time = 1160
.meas tran vdout1_31ck115 FIND v(dout1_31) AT=1160.05n

* CHECK dout1_0 Vdout1_0ck117 = 0 time = 1180
.meas tran vdout1_0ck117 FIND v(dout1_0) AT=1180.05n

* CHECK dout1_1 Vdout1_1ck117 = 1.8 time = 1180
.meas tran vdout1_1ck117 FIND v(dout1_1) AT=1180.05n

* CHECK dout1_2 Vdout1_2ck117 = 1.8 time = 1180
.meas tran vdout1_2ck117 FIND v(dout1_2) AT=1180.05n

* CHECK dout1_3 Vdout1_3ck117 = 1.8 time = 1180
.meas tran vdout1_3ck117 FIND v(dout1_3) AT=1180.05n

* CHECK dout1_4 Vdout1_4ck117 = 1.8 time = 1180
.meas tran vdout1_4ck117 FIND v(dout1_4) AT=1180.05n

* CHECK dout1_5 Vdout1_5ck117 = 0 time = 1180
.meas tran vdout1_5ck117 FIND v(dout1_5) AT=1180.05n

* CHECK dout1_6 Vdout1_6ck117 = 1.8 time = 1180
.meas tran vdout1_6ck117 FIND v(dout1_6) AT=1180.05n

* CHECK dout1_7 Vdout1_7ck117 = 0 time = 1180
.meas tran vdout1_7ck117 FIND v(dout1_7) AT=1180.05n

* CHECK dout1_8 Vdout1_8ck117 = 0 time = 1180
.meas tran vdout1_8ck117 FIND v(dout1_8) AT=1180.05n

* CHECK dout1_9 Vdout1_9ck117 = 1.8 time = 1180
.meas tran vdout1_9ck117 FIND v(dout1_9) AT=1180.05n

* CHECK dout1_10 Vdout1_10ck117 = 1.8 time = 1180
.meas tran vdout1_10ck117 FIND v(dout1_10) AT=1180.05n

* CHECK dout1_11 Vdout1_11ck117 = 0 time = 1180
.meas tran vdout1_11ck117 FIND v(dout1_11) AT=1180.05n

* CHECK dout1_12 Vdout1_12ck117 = 0 time = 1180
.meas tran vdout1_12ck117 FIND v(dout1_12) AT=1180.05n

* CHECK dout1_13 Vdout1_13ck117 = 1.8 time = 1180
.meas tran vdout1_13ck117 FIND v(dout1_13) AT=1180.05n

* CHECK dout1_14 Vdout1_14ck117 = 1.8 time = 1180
.meas tran vdout1_14ck117 FIND v(dout1_14) AT=1180.05n

* CHECK dout1_15 Vdout1_15ck117 = 0 time = 1180
.meas tran vdout1_15ck117 FIND v(dout1_15) AT=1180.05n

* CHECK dout1_16 Vdout1_16ck117 = 0 time = 1180
.meas tran vdout1_16ck117 FIND v(dout1_16) AT=1180.05n

* CHECK dout1_17 Vdout1_17ck117 = 0 time = 1180
.meas tran vdout1_17ck117 FIND v(dout1_17) AT=1180.05n

* CHECK dout1_18 Vdout1_18ck117 = 1.8 time = 1180
.meas tran vdout1_18ck117 FIND v(dout1_18) AT=1180.05n

* CHECK dout1_19 Vdout1_19ck117 = 1.8 time = 1180
.meas tran vdout1_19ck117 FIND v(dout1_19) AT=1180.05n

* CHECK dout1_20 Vdout1_20ck117 = 1.8 time = 1180
.meas tran vdout1_20ck117 FIND v(dout1_20) AT=1180.05n

* CHECK dout1_21 Vdout1_21ck117 = 1.8 time = 1180
.meas tran vdout1_21ck117 FIND v(dout1_21) AT=1180.05n

* CHECK dout1_22 Vdout1_22ck117 = 1.8 time = 1180
.meas tran vdout1_22ck117 FIND v(dout1_22) AT=1180.05n

* CHECK dout1_23 Vdout1_23ck117 = 1.8 time = 1180
.meas tran vdout1_23ck117 FIND v(dout1_23) AT=1180.05n

* CHECK dout1_24 Vdout1_24ck117 = 1.8 time = 1180
.meas tran vdout1_24ck117 FIND v(dout1_24) AT=1180.05n

* CHECK dout1_25 Vdout1_25ck117 = 0 time = 1180
.meas tran vdout1_25ck117 FIND v(dout1_25) AT=1180.05n

* CHECK dout1_26 Vdout1_26ck117 = 1.8 time = 1180
.meas tran vdout1_26ck117 FIND v(dout1_26) AT=1180.05n

* CHECK dout1_27 Vdout1_27ck117 = 0 time = 1180
.meas tran vdout1_27ck117 FIND v(dout1_27) AT=1180.05n

* CHECK dout1_28 Vdout1_28ck117 = 1.8 time = 1180
.meas tran vdout1_28ck117 FIND v(dout1_28) AT=1180.05n

* CHECK dout1_29 Vdout1_29ck117 = 1.8 time = 1180
.meas tran vdout1_29ck117 FIND v(dout1_29) AT=1180.05n

* CHECK dout1_30 Vdout1_30ck117 = 1.8 time = 1180
.meas tran vdout1_30ck117 FIND v(dout1_30) AT=1180.05n

* CHECK dout1_31 Vdout1_31ck117 = 0 time = 1180
.meas tran vdout1_31ck117 FIND v(dout1_31) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck118 = 0 time = 1190
.meas tran vdout0_0ck118 FIND v(dout0_0) AT=1190.05n

* CHECK dout0_1 Vdout0_1ck118 = 1.8 time = 1190
.meas tran vdout0_1ck118 FIND v(dout0_1) AT=1190.05n

* CHECK dout0_2 Vdout0_2ck118 = 1.8 time = 1190
.meas tran vdout0_2ck118 FIND v(dout0_2) AT=1190.05n

* CHECK dout0_3 Vdout0_3ck118 = 1.8 time = 1190
.meas tran vdout0_3ck118 FIND v(dout0_3) AT=1190.05n

* CHECK dout0_4 Vdout0_4ck118 = 1.8 time = 1190
.meas tran vdout0_4ck118 FIND v(dout0_4) AT=1190.05n

* CHECK dout0_5 Vdout0_5ck118 = 0 time = 1190
.meas tran vdout0_5ck118 FIND v(dout0_5) AT=1190.05n

* CHECK dout0_6 Vdout0_6ck118 = 1.8 time = 1190
.meas tran vdout0_6ck118 FIND v(dout0_6) AT=1190.05n

* CHECK dout0_7 Vdout0_7ck118 = 0 time = 1190
.meas tran vdout0_7ck118 FIND v(dout0_7) AT=1190.05n

* CHECK dout0_8 Vdout0_8ck118 = 0 time = 1190
.meas tran vdout0_8ck118 FIND v(dout0_8) AT=1190.05n

* CHECK dout0_9 Vdout0_9ck118 = 1.8 time = 1190
.meas tran vdout0_9ck118 FIND v(dout0_9) AT=1190.05n

* CHECK dout0_10 Vdout0_10ck118 = 1.8 time = 1190
.meas tran vdout0_10ck118 FIND v(dout0_10) AT=1190.05n

* CHECK dout0_11 Vdout0_11ck118 = 0 time = 1190
.meas tran vdout0_11ck118 FIND v(dout0_11) AT=1190.05n

* CHECK dout0_12 Vdout0_12ck118 = 0 time = 1190
.meas tran vdout0_12ck118 FIND v(dout0_12) AT=1190.05n

* CHECK dout0_13 Vdout0_13ck118 = 1.8 time = 1190
.meas tran vdout0_13ck118 FIND v(dout0_13) AT=1190.05n

* CHECK dout0_14 Vdout0_14ck118 = 1.8 time = 1190
.meas tran vdout0_14ck118 FIND v(dout0_14) AT=1190.05n

* CHECK dout0_15 Vdout0_15ck118 = 0 time = 1190
.meas tran vdout0_15ck118 FIND v(dout0_15) AT=1190.05n

* CHECK dout0_16 Vdout0_16ck118 = 0 time = 1190
.meas tran vdout0_16ck118 FIND v(dout0_16) AT=1190.05n

* CHECK dout0_17 Vdout0_17ck118 = 0 time = 1190
.meas tran vdout0_17ck118 FIND v(dout0_17) AT=1190.05n

* CHECK dout0_18 Vdout0_18ck118 = 1.8 time = 1190
.meas tran vdout0_18ck118 FIND v(dout0_18) AT=1190.05n

* CHECK dout0_19 Vdout0_19ck118 = 1.8 time = 1190
.meas tran vdout0_19ck118 FIND v(dout0_19) AT=1190.05n

* CHECK dout0_20 Vdout0_20ck118 = 1.8 time = 1190
.meas tran vdout0_20ck118 FIND v(dout0_20) AT=1190.05n

* CHECK dout0_21 Vdout0_21ck118 = 1.8 time = 1190
.meas tran vdout0_21ck118 FIND v(dout0_21) AT=1190.05n

* CHECK dout0_22 Vdout0_22ck118 = 1.8 time = 1190
.meas tran vdout0_22ck118 FIND v(dout0_22) AT=1190.05n

* CHECK dout0_23 Vdout0_23ck118 = 1.8 time = 1190
.meas tran vdout0_23ck118 FIND v(dout0_23) AT=1190.05n

* CHECK dout0_24 Vdout0_24ck118 = 1.8 time = 1190
.meas tran vdout0_24ck118 FIND v(dout0_24) AT=1190.05n

* CHECK dout0_25 Vdout0_25ck118 = 0 time = 1190
.meas tran vdout0_25ck118 FIND v(dout0_25) AT=1190.05n

* CHECK dout0_26 Vdout0_26ck118 = 1.8 time = 1190
.meas tran vdout0_26ck118 FIND v(dout0_26) AT=1190.05n

* CHECK dout0_27 Vdout0_27ck118 = 0 time = 1190
.meas tran vdout0_27ck118 FIND v(dout0_27) AT=1190.05n

* CHECK dout0_28 Vdout0_28ck118 = 1.8 time = 1190
.meas tran vdout0_28ck118 FIND v(dout0_28) AT=1190.05n

* CHECK dout0_29 Vdout0_29ck118 = 1.8 time = 1190
.meas tran vdout0_29ck118 FIND v(dout0_29) AT=1190.05n

* CHECK dout0_30 Vdout0_30ck118 = 1.8 time = 1190
.meas tran vdout0_30ck118 FIND v(dout0_30) AT=1190.05n

* CHECK dout0_31 Vdout0_31ck118 = 0 time = 1190
.meas tran vdout0_31ck118 FIND v(dout0_31) AT=1190.05n

* CHECK dout1_0 Vdout1_0ck118 = 0 time = 1190
.meas tran vdout1_0ck118 FIND v(dout1_0) AT=1190.05n

* CHECK dout1_1 Vdout1_1ck118 = 0 time = 1190
.meas tran vdout1_1ck118 FIND v(dout1_1) AT=1190.05n

* CHECK dout1_2 Vdout1_2ck118 = 1.8 time = 1190
.meas tran vdout1_2ck118 FIND v(dout1_2) AT=1190.05n

* CHECK dout1_3 Vdout1_3ck118 = 0 time = 1190
.meas tran vdout1_3ck118 FIND v(dout1_3) AT=1190.05n

* CHECK dout1_4 Vdout1_4ck118 = 1.8 time = 1190
.meas tran vdout1_4ck118 FIND v(dout1_4) AT=1190.05n

* CHECK dout1_5 Vdout1_5ck118 = 1.8 time = 1190
.meas tran vdout1_5ck118 FIND v(dout1_5) AT=1190.05n

* CHECK dout1_6 Vdout1_6ck118 = 0 time = 1190
.meas tran vdout1_6ck118 FIND v(dout1_6) AT=1190.05n

* CHECK dout1_7 Vdout1_7ck118 = 0 time = 1190
.meas tran vdout1_7ck118 FIND v(dout1_7) AT=1190.05n

* CHECK dout1_8 Vdout1_8ck118 = 0 time = 1190
.meas tran vdout1_8ck118 FIND v(dout1_8) AT=1190.05n

* CHECK dout1_9 Vdout1_9ck118 = 0 time = 1190
.meas tran vdout1_9ck118 FIND v(dout1_9) AT=1190.05n

* CHECK dout1_10 Vdout1_10ck118 = 0 time = 1190
.meas tran vdout1_10ck118 FIND v(dout1_10) AT=1190.05n

* CHECK dout1_11 Vdout1_11ck118 = 1.8 time = 1190
.meas tran vdout1_11ck118 FIND v(dout1_11) AT=1190.05n

* CHECK dout1_12 Vdout1_12ck118 = 0 time = 1190
.meas tran vdout1_12ck118 FIND v(dout1_12) AT=1190.05n

* CHECK dout1_13 Vdout1_13ck118 = 0 time = 1190
.meas tran vdout1_13ck118 FIND v(dout1_13) AT=1190.05n

* CHECK dout1_14 Vdout1_14ck118 = 0 time = 1190
.meas tran vdout1_14ck118 FIND v(dout1_14) AT=1190.05n

* CHECK dout1_15 Vdout1_15ck118 = 1.8 time = 1190
.meas tran vdout1_15ck118 FIND v(dout1_15) AT=1190.05n

* CHECK dout1_16 Vdout1_16ck118 = 0 time = 1190
.meas tran vdout1_16ck118 FIND v(dout1_16) AT=1190.05n

* CHECK dout1_17 Vdout1_17ck118 = 0 time = 1190
.meas tran vdout1_17ck118 FIND v(dout1_17) AT=1190.05n

* CHECK dout1_18 Vdout1_18ck118 = 0 time = 1190
.meas tran vdout1_18ck118 FIND v(dout1_18) AT=1190.05n

* CHECK dout1_19 Vdout1_19ck118 = 0 time = 1190
.meas tran vdout1_19ck118 FIND v(dout1_19) AT=1190.05n

* CHECK dout1_20 Vdout1_20ck118 = 1.8 time = 1190
.meas tran vdout1_20ck118 FIND v(dout1_20) AT=1190.05n

* CHECK dout1_21 Vdout1_21ck118 = 1.8 time = 1190
.meas tran vdout1_21ck118 FIND v(dout1_21) AT=1190.05n

* CHECK dout1_22 Vdout1_22ck118 = 0 time = 1190
.meas tran vdout1_22ck118 FIND v(dout1_22) AT=1190.05n

* CHECK dout1_23 Vdout1_23ck118 = 0 time = 1190
.meas tran vdout1_23ck118 FIND v(dout1_23) AT=1190.05n

* CHECK dout1_24 Vdout1_24ck118 = 0 time = 1190
.meas tran vdout1_24ck118 FIND v(dout1_24) AT=1190.05n

* CHECK dout1_25 Vdout1_25ck118 = 1.8 time = 1190
.meas tran vdout1_25ck118 FIND v(dout1_25) AT=1190.05n

* CHECK dout1_26 Vdout1_26ck118 = 0 time = 1190
.meas tran vdout1_26ck118 FIND v(dout1_26) AT=1190.05n

* CHECK dout1_27 Vdout1_27ck118 = 0 time = 1190
.meas tran vdout1_27ck118 FIND v(dout1_27) AT=1190.05n

* CHECK dout1_28 Vdout1_28ck118 = 1.8 time = 1190
.meas tran vdout1_28ck118 FIND v(dout1_28) AT=1190.05n

* CHECK dout1_29 Vdout1_29ck118 = 1.8 time = 1190
.meas tran vdout1_29ck118 FIND v(dout1_29) AT=1190.05n

* CHECK dout1_30 Vdout1_30ck118 = 0 time = 1190
.meas tran vdout1_30ck118 FIND v(dout1_30) AT=1190.05n

* CHECK dout1_31 Vdout1_31ck118 = 0 time = 1190
.meas tran vdout1_31ck118 FIND v(dout1_31) AT=1190.05n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 1220
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=1220.05n

* CHECK dout0_1 Vdout0_1ck121 = 0 time = 1220
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=1220.05n

* CHECK dout0_2 Vdout0_2ck121 = 1.8 time = 1220
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=1220.05n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 1220
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=1220.05n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 1220
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=1220.05n

* CHECK dout0_5 Vdout0_5ck121 = 0 time = 1220
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=1220.05n

* CHECK dout0_6 Vdout0_6ck121 = 1.8 time = 1220
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=1220.05n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 1220
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=1220.05n

* CHECK dout0_8 Vdout0_8ck121 = 0 time = 1220
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=1220.05n

* CHECK dout0_9 Vdout0_9ck121 = 0 time = 1220
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=1220.05n

* CHECK dout0_10 Vdout0_10ck121 = 1.8 time = 1220
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=1220.05n

* CHECK dout0_11 Vdout0_11ck121 = 1.8 time = 1220
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=1220.05n

* CHECK dout0_12 Vdout0_12ck121 = 0 time = 1220
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=1220.05n

* CHECK dout0_13 Vdout0_13ck121 = 1.8 time = 1220
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=1220.05n

* CHECK dout0_14 Vdout0_14ck121 = 1.8 time = 1220
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=1220.05n

* CHECK dout0_15 Vdout0_15ck121 = 1.8 time = 1220
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=1220.05n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 1220
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=1220.05n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 1220
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=1220.05n

* CHECK dout0_18 Vdout0_18ck121 = 0 time = 1220
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=1220.05n

* CHECK dout0_19 Vdout0_19ck121 = 1.8 time = 1220
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=1220.05n

* CHECK dout0_20 Vdout0_20ck121 = 0 time = 1220
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=1220.05n

* CHECK dout0_21 Vdout0_21ck121 = 1.8 time = 1220
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=1220.05n

* CHECK dout0_22 Vdout0_22ck121 = 0 time = 1220
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=1220.05n

* CHECK dout0_23 Vdout0_23ck121 = 1.8 time = 1220
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=1220.05n

* CHECK dout0_24 Vdout0_24ck121 = 0 time = 1220
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=1220.05n

* CHECK dout0_25 Vdout0_25ck121 = 1.8 time = 1220
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=1220.05n

* CHECK dout0_26 Vdout0_26ck121 = 0 time = 1220
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=1220.05n

* CHECK dout0_27 Vdout0_27ck121 = 0 time = 1220
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=1220.05n

* CHECK dout0_28 Vdout0_28ck121 = 0 time = 1220
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=1220.05n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 1220
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=1220.05n

* CHECK dout0_30 Vdout0_30ck121 = 1.8 time = 1220
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=1220.05n

* CHECK dout0_31 Vdout0_31ck121 = 1.8 time = 1220
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=1220.05n

* CHECK dout1_0 Vdout1_0ck123 = 1.8 time = 1240
.meas tran vdout1_0ck123 FIND v(dout1_0) AT=1240.05n

* CHECK dout1_1 Vdout1_1ck123 = 0 time = 1240
.meas tran vdout1_1ck123 FIND v(dout1_1) AT=1240.05n

* CHECK dout1_2 Vdout1_2ck123 = 0 time = 1240
.meas tran vdout1_2ck123 FIND v(dout1_2) AT=1240.05n

* CHECK dout1_3 Vdout1_3ck123 = 0 time = 1240
.meas tran vdout1_3ck123 FIND v(dout1_3) AT=1240.05n

* CHECK dout1_4 Vdout1_4ck123 = 1.8 time = 1240
.meas tran vdout1_4ck123 FIND v(dout1_4) AT=1240.05n

* CHECK dout1_5 Vdout1_5ck123 = 1.8 time = 1240
.meas tran vdout1_5ck123 FIND v(dout1_5) AT=1240.05n

* CHECK dout1_6 Vdout1_6ck123 = 1.8 time = 1240
.meas tran vdout1_6ck123 FIND v(dout1_6) AT=1240.05n

* CHECK dout1_7 Vdout1_7ck123 = 1.8 time = 1240
.meas tran vdout1_7ck123 FIND v(dout1_7) AT=1240.05n

* CHECK dout1_8 Vdout1_8ck123 = 0 time = 1240
.meas tran vdout1_8ck123 FIND v(dout1_8) AT=1240.05n

* CHECK dout1_9 Vdout1_9ck123 = 0 time = 1240
.meas tran vdout1_9ck123 FIND v(dout1_9) AT=1240.05n

* CHECK dout1_10 Vdout1_10ck123 = 0 time = 1240
.meas tran vdout1_10ck123 FIND v(dout1_10) AT=1240.05n

* CHECK dout1_11 Vdout1_11ck123 = 0 time = 1240
.meas tran vdout1_11ck123 FIND v(dout1_11) AT=1240.05n

* CHECK dout1_12 Vdout1_12ck123 = 0 time = 1240
.meas tran vdout1_12ck123 FIND v(dout1_12) AT=1240.05n

* CHECK dout1_13 Vdout1_13ck123 = 0 time = 1240
.meas tran vdout1_13ck123 FIND v(dout1_13) AT=1240.05n

* CHECK dout1_14 Vdout1_14ck123 = 0 time = 1240
.meas tran vdout1_14ck123 FIND v(dout1_14) AT=1240.05n

* CHECK dout1_15 Vdout1_15ck123 = 1.8 time = 1240
.meas tran vdout1_15ck123 FIND v(dout1_15) AT=1240.05n

* CHECK dout1_16 Vdout1_16ck123 = 0 time = 1240
.meas tran vdout1_16ck123 FIND v(dout1_16) AT=1240.05n

* CHECK dout1_17 Vdout1_17ck123 = 1.8 time = 1240
.meas tran vdout1_17ck123 FIND v(dout1_17) AT=1240.05n

* CHECK dout1_18 Vdout1_18ck123 = 0 time = 1240
.meas tran vdout1_18ck123 FIND v(dout1_18) AT=1240.05n

* CHECK dout1_19 Vdout1_19ck123 = 0 time = 1240
.meas tran vdout1_19ck123 FIND v(dout1_19) AT=1240.05n

* CHECK dout1_20 Vdout1_20ck123 = 0 time = 1240
.meas tran vdout1_20ck123 FIND v(dout1_20) AT=1240.05n

* CHECK dout1_21 Vdout1_21ck123 = 1.8 time = 1240
.meas tran vdout1_21ck123 FIND v(dout1_21) AT=1240.05n

* CHECK dout1_22 Vdout1_22ck123 = 0 time = 1240
.meas tran vdout1_22ck123 FIND v(dout1_22) AT=1240.05n

* CHECK dout1_23 Vdout1_23ck123 = 0 time = 1240
.meas tran vdout1_23ck123 FIND v(dout1_23) AT=1240.05n

* CHECK dout1_24 Vdout1_24ck123 = 1.8 time = 1240
.meas tran vdout1_24ck123 FIND v(dout1_24) AT=1240.05n

* CHECK dout1_25 Vdout1_25ck123 = 1.8 time = 1240
.meas tran vdout1_25ck123 FIND v(dout1_25) AT=1240.05n

* CHECK dout1_26 Vdout1_26ck123 = 1.8 time = 1240
.meas tran vdout1_26ck123 FIND v(dout1_26) AT=1240.05n

* CHECK dout1_27 Vdout1_27ck123 = 0 time = 1240
.meas tran vdout1_27ck123 FIND v(dout1_27) AT=1240.05n

* CHECK dout1_28 Vdout1_28ck123 = 0 time = 1240
.meas tran vdout1_28ck123 FIND v(dout1_28) AT=1240.05n

* CHECK dout1_29 Vdout1_29ck123 = 1.8 time = 1240
.meas tran vdout1_29ck123 FIND v(dout1_29) AT=1240.05n

* CHECK dout1_30 Vdout1_30ck123 = 1.8 time = 1240
.meas tran vdout1_30ck123 FIND v(dout1_30) AT=1240.05n

* CHECK dout1_31 Vdout1_31ck123 = 1.8 time = 1240
.meas tran vdout1_31ck123 FIND v(dout1_31) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 1270
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=1270.05n

* CHECK dout0_1 Vdout0_1ck126 = 0 time = 1270
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=1270.05n

* CHECK dout0_2 Vdout0_2ck126 = 1.8 time = 1270
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=1270.05n

* CHECK dout0_3 Vdout0_3ck126 = 0 time = 1270
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=1270.05n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 1270
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=1270.05n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 1270
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=1270.05n

* CHECK dout0_6 Vdout0_6ck126 = 1.8 time = 1270
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=1270.05n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 1270
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=1270.05n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 1270
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=1270.05n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 1270
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=1270.05n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 1270
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=1270.05n

* CHECK dout0_11 Vdout0_11ck126 = 1.8 time = 1270
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=1270.05n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 1270
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=1270.05n

* CHECK dout0_13 Vdout0_13ck126 = 1.8 time = 1270
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=1270.05n

* CHECK dout0_14 Vdout0_14ck126 = 1.8 time = 1270
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=1270.05n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 1270
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=1270.05n

* CHECK dout0_16 Vdout0_16ck126 = 0 time = 1270
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=1270.05n

* CHECK dout0_17 Vdout0_17ck126 = 0 time = 1270
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=1270.05n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 1270
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=1270.05n

* CHECK dout0_19 Vdout0_19ck126 = 1.8 time = 1270
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=1270.05n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 1270
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=1270.05n

* CHECK dout0_21 Vdout0_21ck126 = 1.8 time = 1270
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=1270.05n

* CHECK dout0_22 Vdout0_22ck126 = 0 time = 1270
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=1270.05n

* CHECK dout0_23 Vdout0_23ck126 = 1.8 time = 1270
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=1270.05n

* CHECK dout0_24 Vdout0_24ck126 = 0 time = 1270
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=1270.05n

* CHECK dout0_25 Vdout0_25ck126 = 1.8 time = 1270
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=1270.05n

* CHECK dout0_26 Vdout0_26ck126 = 0 time = 1270
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=1270.05n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 1270
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=1270.05n

* CHECK dout0_28 Vdout0_28ck126 = 0 time = 1270
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=1270.05n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 1270
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=1270.05n

* CHECK dout0_30 Vdout0_30ck126 = 1.8 time = 1270
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=1270.05n

* CHECK dout0_31 Vdout0_31ck126 = 1.8 time = 1270
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=1270.05n

* CHECK dout1_0 Vdout1_0ck127 = 1.8 time = 1280
.meas tran vdout1_0ck127 FIND v(dout1_0) AT=1280.05n

* CHECK dout1_1 Vdout1_1ck127 = 0 time = 1280
.meas tran vdout1_1ck127 FIND v(dout1_1) AT=1280.05n

* CHECK dout1_2 Vdout1_2ck127 = 0 time = 1280
.meas tran vdout1_2ck127 FIND v(dout1_2) AT=1280.05n

* CHECK dout1_3 Vdout1_3ck127 = 0 time = 1280
.meas tran vdout1_3ck127 FIND v(dout1_3) AT=1280.05n

* CHECK dout1_4 Vdout1_4ck127 = 1.8 time = 1280
.meas tran vdout1_4ck127 FIND v(dout1_4) AT=1280.05n

* CHECK dout1_5 Vdout1_5ck127 = 1.8 time = 1280
.meas tran vdout1_5ck127 FIND v(dout1_5) AT=1280.05n

* CHECK dout1_6 Vdout1_6ck127 = 1.8 time = 1280
.meas tran vdout1_6ck127 FIND v(dout1_6) AT=1280.05n

* CHECK dout1_7 Vdout1_7ck127 = 1.8 time = 1280
.meas tran vdout1_7ck127 FIND v(dout1_7) AT=1280.05n

* CHECK dout1_8 Vdout1_8ck127 = 0 time = 1280
.meas tran vdout1_8ck127 FIND v(dout1_8) AT=1280.05n

* CHECK dout1_9 Vdout1_9ck127 = 0 time = 1280
.meas tran vdout1_9ck127 FIND v(dout1_9) AT=1280.05n

* CHECK dout1_10 Vdout1_10ck127 = 0 time = 1280
.meas tran vdout1_10ck127 FIND v(dout1_10) AT=1280.05n

* CHECK dout1_11 Vdout1_11ck127 = 0 time = 1280
.meas tran vdout1_11ck127 FIND v(dout1_11) AT=1280.05n

* CHECK dout1_12 Vdout1_12ck127 = 0 time = 1280
.meas tran vdout1_12ck127 FIND v(dout1_12) AT=1280.05n

* CHECK dout1_13 Vdout1_13ck127 = 0 time = 1280
.meas tran vdout1_13ck127 FIND v(dout1_13) AT=1280.05n

* CHECK dout1_14 Vdout1_14ck127 = 0 time = 1280
.meas tran vdout1_14ck127 FIND v(dout1_14) AT=1280.05n

* CHECK dout1_15 Vdout1_15ck127 = 1.8 time = 1280
.meas tran vdout1_15ck127 FIND v(dout1_15) AT=1280.05n

* CHECK dout1_16 Vdout1_16ck127 = 0 time = 1280
.meas tran vdout1_16ck127 FIND v(dout1_16) AT=1280.05n

* CHECK dout1_17 Vdout1_17ck127 = 1.8 time = 1280
.meas tran vdout1_17ck127 FIND v(dout1_17) AT=1280.05n

* CHECK dout1_18 Vdout1_18ck127 = 0 time = 1280
.meas tran vdout1_18ck127 FIND v(dout1_18) AT=1280.05n

* CHECK dout1_19 Vdout1_19ck127 = 0 time = 1280
.meas tran vdout1_19ck127 FIND v(dout1_19) AT=1280.05n

* CHECK dout1_20 Vdout1_20ck127 = 0 time = 1280
.meas tran vdout1_20ck127 FIND v(dout1_20) AT=1280.05n

* CHECK dout1_21 Vdout1_21ck127 = 1.8 time = 1280
.meas tran vdout1_21ck127 FIND v(dout1_21) AT=1280.05n

* CHECK dout1_22 Vdout1_22ck127 = 0 time = 1280
.meas tran vdout1_22ck127 FIND v(dout1_22) AT=1280.05n

* CHECK dout1_23 Vdout1_23ck127 = 0 time = 1280
.meas tran vdout1_23ck127 FIND v(dout1_23) AT=1280.05n

* CHECK dout1_24 Vdout1_24ck127 = 1.8 time = 1280
.meas tran vdout1_24ck127 FIND v(dout1_24) AT=1280.05n

* CHECK dout1_25 Vdout1_25ck127 = 1.8 time = 1280
.meas tran vdout1_25ck127 FIND v(dout1_25) AT=1280.05n

* CHECK dout1_26 Vdout1_26ck127 = 1.8 time = 1280
.meas tran vdout1_26ck127 FIND v(dout1_26) AT=1280.05n

* CHECK dout1_27 Vdout1_27ck127 = 0 time = 1280
.meas tran vdout1_27ck127 FIND v(dout1_27) AT=1280.05n

* CHECK dout1_28 Vdout1_28ck127 = 0 time = 1280
.meas tran vdout1_28ck127 FIND v(dout1_28) AT=1280.05n

* CHECK dout1_29 Vdout1_29ck127 = 1.8 time = 1280
.meas tran vdout1_29ck127 FIND v(dout1_29) AT=1280.05n

* CHECK dout1_30 Vdout1_30ck127 = 1.8 time = 1280
.meas tran vdout1_30ck127 FIND v(dout1_30) AT=1280.05n

* CHECK dout1_31 Vdout1_31ck127 = 1.8 time = 1280
.meas tran vdout1_31ck127 FIND v(dout1_31) AT=1280.05n

* CHECK dout0_0 Vdout0_0ck128 = 1.8 time = 1290
.meas tran vdout0_0ck128 FIND v(dout0_0) AT=1290.05n

* CHECK dout0_1 Vdout0_1ck128 = 0 time = 1290
.meas tran vdout0_1ck128 FIND v(dout0_1) AT=1290.05n

* CHECK dout0_2 Vdout0_2ck128 = 0 time = 1290
.meas tran vdout0_2ck128 FIND v(dout0_2) AT=1290.05n

* CHECK dout0_3 Vdout0_3ck128 = 0 time = 1290
.meas tran vdout0_3ck128 FIND v(dout0_3) AT=1290.05n

* CHECK dout0_4 Vdout0_4ck128 = 1.8 time = 1290
.meas tran vdout0_4ck128 FIND v(dout0_4) AT=1290.05n

* CHECK dout0_5 Vdout0_5ck128 = 1.8 time = 1290
.meas tran vdout0_5ck128 FIND v(dout0_5) AT=1290.05n

* CHECK dout0_6 Vdout0_6ck128 = 1.8 time = 1290
.meas tran vdout0_6ck128 FIND v(dout0_6) AT=1290.05n

* CHECK dout0_7 Vdout0_7ck128 = 1.8 time = 1290
.meas tran vdout0_7ck128 FIND v(dout0_7) AT=1290.05n

* CHECK dout0_8 Vdout0_8ck128 = 0 time = 1290
.meas tran vdout0_8ck128 FIND v(dout0_8) AT=1290.05n

* CHECK dout0_9 Vdout0_9ck128 = 0 time = 1290
.meas tran vdout0_9ck128 FIND v(dout0_9) AT=1290.05n

* CHECK dout0_10 Vdout0_10ck128 = 0 time = 1290
.meas tran vdout0_10ck128 FIND v(dout0_10) AT=1290.05n

* CHECK dout0_11 Vdout0_11ck128 = 0 time = 1290
.meas tran vdout0_11ck128 FIND v(dout0_11) AT=1290.05n

* CHECK dout0_12 Vdout0_12ck128 = 0 time = 1290
.meas tran vdout0_12ck128 FIND v(dout0_12) AT=1290.05n

* CHECK dout0_13 Vdout0_13ck128 = 0 time = 1290
.meas tran vdout0_13ck128 FIND v(dout0_13) AT=1290.05n

* CHECK dout0_14 Vdout0_14ck128 = 0 time = 1290
.meas tran vdout0_14ck128 FIND v(dout0_14) AT=1290.05n

* CHECK dout0_15 Vdout0_15ck128 = 1.8 time = 1290
.meas tran vdout0_15ck128 FIND v(dout0_15) AT=1290.05n

* CHECK dout0_16 Vdout0_16ck128 = 0 time = 1290
.meas tran vdout0_16ck128 FIND v(dout0_16) AT=1290.05n

* CHECK dout0_17 Vdout0_17ck128 = 1.8 time = 1290
.meas tran vdout0_17ck128 FIND v(dout0_17) AT=1290.05n

* CHECK dout0_18 Vdout0_18ck128 = 0 time = 1290
.meas tran vdout0_18ck128 FIND v(dout0_18) AT=1290.05n

* CHECK dout0_19 Vdout0_19ck128 = 0 time = 1290
.meas tran vdout0_19ck128 FIND v(dout0_19) AT=1290.05n

* CHECK dout0_20 Vdout0_20ck128 = 0 time = 1290
.meas tran vdout0_20ck128 FIND v(dout0_20) AT=1290.05n

* CHECK dout0_21 Vdout0_21ck128 = 1.8 time = 1290
.meas tran vdout0_21ck128 FIND v(dout0_21) AT=1290.05n

* CHECK dout0_22 Vdout0_22ck128 = 0 time = 1290
.meas tran vdout0_22ck128 FIND v(dout0_22) AT=1290.05n

* CHECK dout0_23 Vdout0_23ck128 = 0 time = 1290
.meas tran vdout0_23ck128 FIND v(dout0_23) AT=1290.05n

* CHECK dout0_24 Vdout0_24ck128 = 1.8 time = 1290
.meas tran vdout0_24ck128 FIND v(dout0_24) AT=1290.05n

* CHECK dout0_25 Vdout0_25ck128 = 1.8 time = 1290
.meas tran vdout0_25ck128 FIND v(dout0_25) AT=1290.05n

* CHECK dout0_26 Vdout0_26ck128 = 1.8 time = 1290
.meas tran vdout0_26ck128 FIND v(dout0_26) AT=1290.05n

* CHECK dout0_27 Vdout0_27ck128 = 0 time = 1290
.meas tran vdout0_27ck128 FIND v(dout0_27) AT=1290.05n

* CHECK dout0_28 Vdout0_28ck128 = 0 time = 1290
.meas tran vdout0_28ck128 FIND v(dout0_28) AT=1290.05n

* CHECK dout0_29 Vdout0_29ck128 = 1.8 time = 1290
.meas tran vdout0_29ck128 FIND v(dout0_29) AT=1290.05n

* CHECK dout0_30 Vdout0_30ck128 = 1.8 time = 1290
.meas tran vdout0_30ck128 FIND v(dout0_30) AT=1290.05n

* CHECK dout0_31 Vdout0_31ck128 = 1.8 time = 1290
.meas tran vdout0_31ck128 FIND v(dout0_31) AT=1290.05n

* CHECK dout1_0 Vdout1_0ck131 = 0 time = 1320
.meas tran vdout1_0ck131 FIND v(dout1_0) AT=1320.05n

* CHECK dout1_1 Vdout1_1ck131 = 0 time = 1320
.meas tran vdout1_1ck131 FIND v(dout1_1) AT=1320.05n

* CHECK dout1_2 Vdout1_2ck131 = 1.8 time = 1320
.meas tran vdout1_2ck131 FIND v(dout1_2) AT=1320.05n

* CHECK dout1_3 Vdout1_3ck131 = 0 time = 1320
.meas tran vdout1_3ck131 FIND v(dout1_3) AT=1320.05n

* CHECK dout1_4 Vdout1_4ck131 = 0 time = 1320
.meas tran vdout1_4ck131 FIND v(dout1_4) AT=1320.05n

* CHECK dout1_5 Vdout1_5ck131 = 0 time = 1320
.meas tran vdout1_5ck131 FIND v(dout1_5) AT=1320.05n

* CHECK dout1_6 Vdout1_6ck131 = 1.8 time = 1320
.meas tran vdout1_6ck131 FIND v(dout1_6) AT=1320.05n

* CHECK dout1_7 Vdout1_7ck131 = 0 time = 1320
.meas tran vdout1_7ck131 FIND v(dout1_7) AT=1320.05n

* CHECK dout1_8 Vdout1_8ck131 = 0 time = 1320
.meas tran vdout1_8ck131 FIND v(dout1_8) AT=1320.05n

* CHECK dout1_9 Vdout1_9ck131 = 0 time = 1320
.meas tran vdout1_9ck131 FIND v(dout1_9) AT=1320.05n

* CHECK dout1_10 Vdout1_10ck131 = 1.8 time = 1320
.meas tran vdout1_10ck131 FIND v(dout1_10) AT=1320.05n

* CHECK dout1_11 Vdout1_11ck131 = 1.8 time = 1320
.meas tran vdout1_11ck131 FIND v(dout1_11) AT=1320.05n

* CHECK dout1_12 Vdout1_12ck131 = 0 time = 1320
.meas tran vdout1_12ck131 FIND v(dout1_12) AT=1320.05n

* CHECK dout1_13 Vdout1_13ck131 = 1.8 time = 1320
.meas tran vdout1_13ck131 FIND v(dout1_13) AT=1320.05n

* CHECK dout1_14 Vdout1_14ck131 = 1.8 time = 1320
.meas tran vdout1_14ck131 FIND v(dout1_14) AT=1320.05n

* CHECK dout1_15 Vdout1_15ck131 = 1.8 time = 1320
.meas tran vdout1_15ck131 FIND v(dout1_15) AT=1320.05n

* CHECK dout1_16 Vdout1_16ck131 = 0 time = 1320
.meas tran vdout1_16ck131 FIND v(dout1_16) AT=1320.05n

* CHECK dout1_17 Vdout1_17ck131 = 0 time = 1320
.meas tran vdout1_17ck131 FIND v(dout1_17) AT=1320.05n

* CHECK dout1_18 Vdout1_18ck131 = 0 time = 1320
.meas tran vdout1_18ck131 FIND v(dout1_18) AT=1320.05n

* CHECK dout1_19 Vdout1_19ck131 = 1.8 time = 1320
.meas tran vdout1_19ck131 FIND v(dout1_19) AT=1320.05n

* CHECK dout1_20 Vdout1_20ck131 = 0 time = 1320
.meas tran vdout1_20ck131 FIND v(dout1_20) AT=1320.05n

* CHECK dout1_21 Vdout1_21ck131 = 1.8 time = 1320
.meas tran vdout1_21ck131 FIND v(dout1_21) AT=1320.05n

* CHECK dout1_22 Vdout1_22ck131 = 0 time = 1320
.meas tran vdout1_22ck131 FIND v(dout1_22) AT=1320.05n

* CHECK dout1_23 Vdout1_23ck131 = 1.8 time = 1320
.meas tran vdout1_23ck131 FIND v(dout1_23) AT=1320.05n

* CHECK dout1_24 Vdout1_24ck131 = 0 time = 1320
.meas tran vdout1_24ck131 FIND v(dout1_24) AT=1320.05n

* CHECK dout1_25 Vdout1_25ck131 = 1.8 time = 1320
.meas tran vdout1_25ck131 FIND v(dout1_25) AT=1320.05n

* CHECK dout1_26 Vdout1_26ck131 = 0 time = 1320
.meas tran vdout1_26ck131 FIND v(dout1_26) AT=1320.05n

* CHECK dout1_27 Vdout1_27ck131 = 0 time = 1320
.meas tran vdout1_27ck131 FIND v(dout1_27) AT=1320.05n

* CHECK dout1_28 Vdout1_28ck131 = 0 time = 1320
.meas tran vdout1_28ck131 FIND v(dout1_28) AT=1320.05n

* CHECK dout1_29 Vdout1_29ck131 = 0 time = 1320
.meas tran vdout1_29ck131 FIND v(dout1_29) AT=1320.05n

* CHECK dout1_30 Vdout1_30ck131 = 1.8 time = 1320
.meas tran vdout1_30ck131 FIND v(dout1_30) AT=1320.05n

* CHECK dout1_31 Vdout1_31ck131 = 1.8 time = 1320
.meas tran vdout1_31ck131 FIND v(dout1_31) AT=1320.05n

* CHECK dout1_0 Vdout1_0ck132 = 0 time = 1330
.meas tran vdout1_0ck132 FIND v(dout1_0) AT=1330.05n

* CHECK dout1_1 Vdout1_1ck132 = 0 time = 1330
.meas tran vdout1_1ck132 FIND v(dout1_1) AT=1330.05n

* CHECK dout1_2 Vdout1_2ck132 = 0 time = 1330
.meas tran vdout1_2ck132 FIND v(dout1_2) AT=1330.05n

* CHECK dout1_3 Vdout1_3ck132 = 0 time = 1330
.meas tran vdout1_3ck132 FIND v(dout1_3) AT=1330.05n

* CHECK dout1_4 Vdout1_4ck132 = 0 time = 1330
.meas tran vdout1_4ck132 FIND v(dout1_4) AT=1330.05n

* CHECK dout1_5 Vdout1_5ck132 = 1.8 time = 1330
.meas tran vdout1_5ck132 FIND v(dout1_5) AT=1330.05n

* CHECK dout1_6 Vdout1_6ck132 = 1.8 time = 1330
.meas tran vdout1_6ck132 FIND v(dout1_6) AT=1330.05n

* CHECK dout1_7 Vdout1_7ck132 = 1.8 time = 1330
.meas tran vdout1_7ck132 FIND v(dout1_7) AT=1330.05n

* CHECK dout1_8 Vdout1_8ck132 = 0 time = 1330
.meas tran vdout1_8ck132 FIND v(dout1_8) AT=1330.05n

* CHECK dout1_9 Vdout1_9ck132 = 0 time = 1330
.meas tran vdout1_9ck132 FIND v(dout1_9) AT=1330.05n

* CHECK dout1_10 Vdout1_10ck132 = 0 time = 1330
.meas tran vdout1_10ck132 FIND v(dout1_10) AT=1330.05n

* CHECK dout1_11 Vdout1_11ck132 = 0 time = 1330
.meas tran vdout1_11ck132 FIND v(dout1_11) AT=1330.05n

* CHECK dout1_12 Vdout1_12ck132 = 0 time = 1330
.meas tran vdout1_12ck132 FIND v(dout1_12) AT=1330.05n

* CHECK dout1_13 Vdout1_13ck132 = 0 time = 1330
.meas tran vdout1_13ck132 FIND v(dout1_13) AT=1330.05n

* CHECK dout1_14 Vdout1_14ck132 = 0 time = 1330
.meas tran vdout1_14ck132 FIND v(dout1_14) AT=1330.05n

* CHECK dout1_15 Vdout1_15ck132 = 1.8 time = 1330
.meas tran vdout1_15ck132 FIND v(dout1_15) AT=1330.05n

* CHECK dout1_16 Vdout1_16ck132 = 1.8 time = 1330
.meas tran vdout1_16ck132 FIND v(dout1_16) AT=1330.05n

* CHECK dout1_17 Vdout1_17ck132 = 1.8 time = 1330
.meas tran vdout1_17ck132 FIND v(dout1_17) AT=1330.05n

* CHECK dout1_18 Vdout1_18ck132 = 1.8 time = 1330
.meas tran vdout1_18ck132 FIND v(dout1_18) AT=1330.05n

* CHECK dout1_19 Vdout1_19ck132 = 0 time = 1330
.meas tran vdout1_19ck132 FIND v(dout1_19) AT=1330.05n

* CHECK dout1_20 Vdout1_20ck132 = 0 time = 1330
.meas tran vdout1_20ck132 FIND v(dout1_20) AT=1330.05n

* CHECK dout1_21 Vdout1_21ck132 = 0 time = 1330
.meas tran vdout1_21ck132 FIND v(dout1_21) AT=1330.05n

* CHECK dout1_22 Vdout1_22ck132 = 1.8 time = 1330
.meas tran vdout1_22ck132 FIND v(dout1_22) AT=1330.05n

* CHECK dout1_23 Vdout1_23ck132 = 0 time = 1330
.meas tran vdout1_23ck132 FIND v(dout1_23) AT=1330.05n

* CHECK dout1_24 Vdout1_24ck132 = 1.8 time = 1330
.meas tran vdout1_24ck132 FIND v(dout1_24) AT=1330.05n

* CHECK dout1_25 Vdout1_25ck132 = 1.8 time = 1330
.meas tran vdout1_25ck132 FIND v(dout1_25) AT=1330.05n

* CHECK dout1_26 Vdout1_26ck132 = 1.8 time = 1330
.meas tran vdout1_26ck132 FIND v(dout1_26) AT=1330.05n

* CHECK dout1_27 Vdout1_27ck132 = 0 time = 1330
.meas tran vdout1_27ck132 FIND v(dout1_27) AT=1330.05n

* CHECK dout1_28 Vdout1_28ck132 = 0 time = 1330
.meas tran vdout1_28ck132 FIND v(dout1_28) AT=1330.05n

* CHECK dout1_29 Vdout1_29ck132 = 1.8 time = 1330
.meas tran vdout1_29ck132 FIND v(dout1_29) AT=1330.05n

* CHECK dout1_30 Vdout1_30ck132 = 1.8 time = 1330
.meas tran vdout1_30ck132 FIND v(dout1_30) AT=1330.05n

* CHECK dout1_31 Vdout1_31ck132 = 1.8 time = 1330
.meas tran vdout1_31ck132 FIND v(dout1_31) AT=1330.05n

* CHECK dout1_0 Vdout1_0ck133 = 0 time = 1340
.meas tran vdout1_0ck133 FIND v(dout1_0) AT=1340.05n

* CHECK dout1_1 Vdout1_1ck133 = 0 time = 1340
.meas tran vdout1_1ck133 FIND v(dout1_1) AT=1340.05n

* CHECK dout1_2 Vdout1_2ck133 = 0 time = 1340
.meas tran vdout1_2ck133 FIND v(dout1_2) AT=1340.05n

* CHECK dout1_3 Vdout1_3ck133 = 0 time = 1340
.meas tran vdout1_3ck133 FIND v(dout1_3) AT=1340.05n

* CHECK dout1_4 Vdout1_4ck133 = 0 time = 1340
.meas tran vdout1_4ck133 FIND v(dout1_4) AT=1340.05n

* CHECK dout1_5 Vdout1_5ck133 = 1.8 time = 1340
.meas tran vdout1_5ck133 FIND v(dout1_5) AT=1340.05n

* CHECK dout1_6 Vdout1_6ck133 = 1.8 time = 1340
.meas tran vdout1_6ck133 FIND v(dout1_6) AT=1340.05n

* CHECK dout1_7 Vdout1_7ck133 = 1.8 time = 1340
.meas tran vdout1_7ck133 FIND v(dout1_7) AT=1340.05n

* CHECK dout1_8 Vdout1_8ck133 = 0 time = 1340
.meas tran vdout1_8ck133 FIND v(dout1_8) AT=1340.05n

* CHECK dout1_9 Vdout1_9ck133 = 0 time = 1340
.meas tran vdout1_9ck133 FIND v(dout1_9) AT=1340.05n

* CHECK dout1_10 Vdout1_10ck133 = 0 time = 1340
.meas tran vdout1_10ck133 FIND v(dout1_10) AT=1340.05n

* CHECK dout1_11 Vdout1_11ck133 = 0 time = 1340
.meas tran vdout1_11ck133 FIND v(dout1_11) AT=1340.05n

* CHECK dout1_12 Vdout1_12ck133 = 0 time = 1340
.meas tran vdout1_12ck133 FIND v(dout1_12) AT=1340.05n

* CHECK dout1_13 Vdout1_13ck133 = 0 time = 1340
.meas tran vdout1_13ck133 FIND v(dout1_13) AT=1340.05n

* CHECK dout1_14 Vdout1_14ck133 = 0 time = 1340
.meas tran vdout1_14ck133 FIND v(dout1_14) AT=1340.05n

* CHECK dout1_15 Vdout1_15ck133 = 1.8 time = 1340
.meas tran vdout1_15ck133 FIND v(dout1_15) AT=1340.05n

* CHECK dout1_16 Vdout1_16ck133 = 1.8 time = 1340
.meas tran vdout1_16ck133 FIND v(dout1_16) AT=1340.05n

* CHECK dout1_17 Vdout1_17ck133 = 1.8 time = 1340
.meas tran vdout1_17ck133 FIND v(dout1_17) AT=1340.05n

* CHECK dout1_18 Vdout1_18ck133 = 1.8 time = 1340
.meas tran vdout1_18ck133 FIND v(dout1_18) AT=1340.05n

* CHECK dout1_19 Vdout1_19ck133 = 0 time = 1340
.meas tran vdout1_19ck133 FIND v(dout1_19) AT=1340.05n

* CHECK dout1_20 Vdout1_20ck133 = 0 time = 1340
.meas tran vdout1_20ck133 FIND v(dout1_20) AT=1340.05n

* CHECK dout1_21 Vdout1_21ck133 = 0 time = 1340
.meas tran vdout1_21ck133 FIND v(dout1_21) AT=1340.05n

* CHECK dout1_22 Vdout1_22ck133 = 1.8 time = 1340
.meas tran vdout1_22ck133 FIND v(dout1_22) AT=1340.05n

* CHECK dout1_23 Vdout1_23ck133 = 0 time = 1340
.meas tran vdout1_23ck133 FIND v(dout1_23) AT=1340.05n

* CHECK dout1_24 Vdout1_24ck133 = 1.8 time = 1340
.meas tran vdout1_24ck133 FIND v(dout1_24) AT=1340.05n

* CHECK dout1_25 Vdout1_25ck133 = 1.8 time = 1340
.meas tran vdout1_25ck133 FIND v(dout1_25) AT=1340.05n

* CHECK dout1_26 Vdout1_26ck133 = 1.8 time = 1340
.meas tran vdout1_26ck133 FIND v(dout1_26) AT=1340.05n

* CHECK dout1_27 Vdout1_27ck133 = 0 time = 1340
.meas tran vdout1_27ck133 FIND v(dout1_27) AT=1340.05n

* CHECK dout1_28 Vdout1_28ck133 = 0 time = 1340
.meas tran vdout1_28ck133 FIND v(dout1_28) AT=1340.05n

* CHECK dout1_29 Vdout1_29ck133 = 1.8 time = 1340
.meas tran vdout1_29ck133 FIND v(dout1_29) AT=1340.05n

* CHECK dout1_30 Vdout1_30ck133 = 1.8 time = 1340
.meas tran vdout1_30ck133 FIND v(dout1_30) AT=1340.05n

* CHECK dout1_31 Vdout1_31ck133 = 1.8 time = 1340
.meas tran vdout1_31ck133 FIND v(dout1_31) AT=1340.05n

* CHECK dout1_0 Vdout1_0ck135 = 0 time = 1360
.meas tran vdout1_0ck135 FIND v(dout1_0) AT=1360.05n

* CHECK dout1_1 Vdout1_1ck135 = 0 time = 1360
.meas tran vdout1_1ck135 FIND v(dout1_1) AT=1360.05n

* CHECK dout1_2 Vdout1_2ck135 = 1.8 time = 1360
.meas tran vdout1_2ck135 FIND v(dout1_2) AT=1360.05n

* CHECK dout1_3 Vdout1_3ck135 = 0 time = 1360
.meas tran vdout1_3ck135 FIND v(dout1_3) AT=1360.05n

* CHECK dout1_4 Vdout1_4ck135 = 0 time = 1360
.meas tran vdout1_4ck135 FIND v(dout1_4) AT=1360.05n

* CHECK dout1_5 Vdout1_5ck135 = 0 time = 1360
.meas tran vdout1_5ck135 FIND v(dout1_5) AT=1360.05n

* CHECK dout1_6 Vdout1_6ck135 = 1.8 time = 1360
.meas tran vdout1_6ck135 FIND v(dout1_6) AT=1360.05n

* CHECK dout1_7 Vdout1_7ck135 = 0 time = 1360
.meas tran vdout1_7ck135 FIND v(dout1_7) AT=1360.05n

* CHECK dout1_8 Vdout1_8ck135 = 0 time = 1360
.meas tran vdout1_8ck135 FIND v(dout1_8) AT=1360.05n

* CHECK dout1_9 Vdout1_9ck135 = 0 time = 1360
.meas tran vdout1_9ck135 FIND v(dout1_9) AT=1360.05n

* CHECK dout1_10 Vdout1_10ck135 = 1.8 time = 1360
.meas tran vdout1_10ck135 FIND v(dout1_10) AT=1360.05n

* CHECK dout1_11 Vdout1_11ck135 = 1.8 time = 1360
.meas tran vdout1_11ck135 FIND v(dout1_11) AT=1360.05n

* CHECK dout1_12 Vdout1_12ck135 = 0 time = 1360
.meas tran vdout1_12ck135 FIND v(dout1_12) AT=1360.05n

* CHECK dout1_13 Vdout1_13ck135 = 1.8 time = 1360
.meas tran vdout1_13ck135 FIND v(dout1_13) AT=1360.05n

* CHECK dout1_14 Vdout1_14ck135 = 1.8 time = 1360
.meas tran vdout1_14ck135 FIND v(dout1_14) AT=1360.05n

* CHECK dout1_15 Vdout1_15ck135 = 1.8 time = 1360
.meas tran vdout1_15ck135 FIND v(dout1_15) AT=1360.05n

* CHECK dout1_16 Vdout1_16ck135 = 0 time = 1360
.meas tran vdout1_16ck135 FIND v(dout1_16) AT=1360.05n

* CHECK dout1_17 Vdout1_17ck135 = 0 time = 1360
.meas tran vdout1_17ck135 FIND v(dout1_17) AT=1360.05n

* CHECK dout1_18 Vdout1_18ck135 = 0 time = 1360
.meas tran vdout1_18ck135 FIND v(dout1_18) AT=1360.05n

* CHECK dout1_19 Vdout1_19ck135 = 1.8 time = 1360
.meas tran vdout1_19ck135 FIND v(dout1_19) AT=1360.05n

* CHECK dout1_20 Vdout1_20ck135 = 0 time = 1360
.meas tran vdout1_20ck135 FIND v(dout1_20) AT=1360.05n

* CHECK dout1_21 Vdout1_21ck135 = 1.8 time = 1360
.meas tran vdout1_21ck135 FIND v(dout1_21) AT=1360.05n

* CHECK dout1_22 Vdout1_22ck135 = 0 time = 1360
.meas tran vdout1_22ck135 FIND v(dout1_22) AT=1360.05n

* CHECK dout1_23 Vdout1_23ck135 = 1.8 time = 1360
.meas tran vdout1_23ck135 FIND v(dout1_23) AT=1360.05n

* CHECK dout1_24 Vdout1_24ck135 = 0 time = 1360
.meas tran vdout1_24ck135 FIND v(dout1_24) AT=1360.05n

* CHECK dout1_25 Vdout1_25ck135 = 1.8 time = 1360
.meas tran vdout1_25ck135 FIND v(dout1_25) AT=1360.05n

* CHECK dout1_26 Vdout1_26ck135 = 0 time = 1360
.meas tran vdout1_26ck135 FIND v(dout1_26) AT=1360.05n

* CHECK dout1_27 Vdout1_27ck135 = 0 time = 1360
.meas tran vdout1_27ck135 FIND v(dout1_27) AT=1360.05n

* CHECK dout1_28 Vdout1_28ck135 = 0 time = 1360
.meas tran vdout1_28ck135 FIND v(dout1_28) AT=1360.05n

* CHECK dout1_29 Vdout1_29ck135 = 0 time = 1360
.meas tran vdout1_29ck135 FIND v(dout1_29) AT=1360.05n

* CHECK dout1_30 Vdout1_30ck135 = 1.8 time = 1360
.meas tran vdout1_30ck135 FIND v(dout1_30) AT=1360.05n

* CHECK dout1_31 Vdout1_31ck135 = 1.8 time = 1360
.meas tran vdout1_31ck135 FIND v(dout1_31) AT=1360.05n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 1370
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=1370.05n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 1370
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=1370.05n

* CHECK dout0_2 Vdout0_2ck136 = 1.8 time = 1370
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=1370.05n

* CHECK dout0_3 Vdout0_3ck136 = 0 time = 1370
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=1370.05n

* CHECK dout0_4 Vdout0_4ck136 = 0 time = 1370
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=1370.05n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 1370
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=1370.05n

* CHECK dout0_6 Vdout0_6ck136 = 1.8 time = 1370
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=1370.05n

* CHECK dout0_7 Vdout0_7ck136 = 0 time = 1370
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=1370.05n

* CHECK dout0_8 Vdout0_8ck136 = 0 time = 1370
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=1370.05n

* CHECK dout0_9 Vdout0_9ck136 = 0 time = 1370
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=1370.05n

* CHECK dout0_10 Vdout0_10ck136 = 1.8 time = 1370
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=1370.05n

* CHECK dout0_11 Vdout0_11ck136 = 1.8 time = 1370
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=1370.05n

* CHECK dout0_12 Vdout0_12ck136 = 0 time = 1370
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=1370.05n

* CHECK dout0_13 Vdout0_13ck136 = 1.8 time = 1370
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=1370.05n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 1370
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=1370.05n

* CHECK dout0_15 Vdout0_15ck136 = 1.8 time = 1370
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=1370.05n

* CHECK dout0_16 Vdout0_16ck136 = 0 time = 1370
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=1370.05n

* CHECK dout0_17 Vdout0_17ck136 = 0 time = 1370
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=1370.05n

* CHECK dout0_18 Vdout0_18ck136 = 0 time = 1370
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=1370.05n

* CHECK dout0_19 Vdout0_19ck136 = 1.8 time = 1370
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=1370.05n

* CHECK dout0_20 Vdout0_20ck136 = 0 time = 1370
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=1370.05n

* CHECK dout0_21 Vdout0_21ck136 = 1.8 time = 1370
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=1370.05n

* CHECK dout0_22 Vdout0_22ck136 = 0 time = 1370
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=1370.05n

* CHECK dout0_23 Vdout0_23ck136 = 1.8 time = 1370
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=1370.05n

* CHECK dout0_24 Vdout0_24ck136 = 0 time = 1370
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=1370.05n

* CHECK dout0_25 Vdout0_25ck136 = 1.8 time = 1370
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=1370.05n

* CHECK dout0_26 Vdout0_26ck136 = 0 time = 1370
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=1370.05n

* CHECK dout0_27 Vdout0_27ck136 = 0 time = 1370
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=1370.05n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 1370
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=1370.05n

* CHECK dout0_29 Vdout0_29ck136 = 0 time = 1370
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=1370.05n

* CHECK dout0_30 Vdout0_30ck136 = 1.8 time = 1370
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=1370.05n

* CHECK dout0_31 Vdout0_31ck136 = 1.8 time = 1370
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=1370.05n

* CHECK dout0_0 Vdout0_0ck137 = 1.8 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 1.8 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 1.8 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 1.8 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 1380
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=1380.05n

* CHECK dout0_9 Vdout0_9ck137 = 1.8 time = 1380
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=1380.05n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 1380
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=1380.05n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 1380
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=1380.05n

* CHECK dout0_12 Vdout0_12ck137 = 0 time = 1380
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=1380.05n

* CHECK dout0_13 Vdout0_13ck137 = 0 time = 1380
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=1380.05n

* CHECK dout0_14 Vdout0_14ck137 = 1.8 time = 1380
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=1380.05n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 1380
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=1380.05n

* CHECK dout0_16 Vdout0_16ck137 = 1.8 time = 1380
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=1380.05n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 1380
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=1380.05n

* CHECK dout0_18 Vdout0_18ck137 = 1.8 time = 1380
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=1380.05n

* CHECK dout0_19 Vdout0_19ck137 = 0 time = 1380
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=1380.05n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 1380
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=1380.05n

* CHECK dout0_21 Vdout0_21ck137 = 0 time = 1380
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=1380.05n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 1380
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=1380.05n

* CHECK dout0_23 Vdout0_23ck137 = 1.8 time = 1380
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=1380.05n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 1380
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=1380.05n

* CHECK dout0_25 Vdout0_25ck137 = 1.8 time = 1380
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=1380.05n

* CHECK dout0_26 Vdout0_26ck137 = 1.8 time = 1380
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=1380.05n

* CHECK dout0_27 Vdout0_27ck137 = 0 time = 1380
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=1380.05n

* CHECK dout0_28 Vdout0_28ck137 = 1.8 time = 1380
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=1380.05n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 1380
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=1380.05n

* CHECK dout0_30 Vdout0_30ck137 = 1.8 time = 1380
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=1380.05n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 1380
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 1.8 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 1400
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=1400.05n

* CHECK dout0_9 Vdout0_9ck139 = 0 time = 1400
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=1400.05n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 1400
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=1400.05n

* CHECK dout0_11 Vdout0_11ck139 = 1.8 time = 1400
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=1400.05n

* CHECK dout0_12 Vdout0_12ck139 = 0 time = 1400
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=1400.05n

* CHECK dout0_13 Vdout0_13ck139 = 1.8 time = 1400
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=1400.05n

* CHECK dout0_14 Vdout0_14ck139 = 1.8 time = 1400
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=1400.05n

* CHECK dout0_15 Vdout0_15ck139 = 1.8 time = 1400
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=1400.05n

* CHECK dout0_16 Vdout0_16ck139 = 0 time = 1400
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=1400.05n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 1400
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=1400.05n

* CHECK dout0_18 Vdout0_18ck139 = 0 time = 1400
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=1400.05n

* CHECK dout0_19 Vdout0_19ck139 = 1.8 time = 1400
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=1400.05n

* CHECK dout0_20 Vdout0_20ck139 = 0 time = 1400
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=1400.05n

* CHECK dout0_21 Vdout0_21ck139 = 1.8 time = 1400
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=1400.05n

* CHECK dout0_22 Vdout0_22ck139 = 0 time = 1400
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=1400.05n

* CHECK dout0_23 Vdout0_23ck139 = 1.8 time = 1400
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=1400.05n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 1400
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=1400.05n

* CHECK dout0_25 Vdout0_25ck139 = 1.8 time = 1400
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=1400.05n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 1400
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=1400.05n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 1400
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=1400.05n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 1400
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=1400.05n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 1400
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=1400.05n

* CHECK dout0_30 Vdout0_30ck139 = 1.8 time = 1400
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=1400.05n

* CHECK dout0_31 Vdout0_31ck139 = 1.8 time = 1400
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck144 = 1.8 time = 1450
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=1450.05n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 1450
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=1450.05n

* CHECK dout0_2 Vdout0_2ck144 = 0 time = 1450
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=1450.05n

* CHECK dout0_3 Vdout0_3ck144 = 0 time = 1450
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=1450.05n

* CHECK dout0_4 Vdout0_4ck144 = 1.8 time = 1450
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=1450.05n

* CHECK dout0_5 Vdout0_5ck144 = 1.8 time = 1450
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=1450.05n

* CHECK dout0_6 Vdout0_6ck144 = 0 time = 1450
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=1450.05n

* CHECK dout0_7 Vdout0_7ck144 = 1.8 time = 1450
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=1450.05n

* CHECK dout0_8 Vdout0_8ck144 = 0 time = 1450
.meas tran vdout0_8ck144 FIND v(dout0_8) AT=1450.05n

* CHECK dout0_9 Vdout0_9ck144 = 0 time = 1450
.meas tran vdout0_9ck144 FIND v(dout0_9) AT=1450.05n

* CHECK dout0_10 Vdout0_10ck144 = 1.8 time = 1450
.meas tran vdout0_10ck144 FIND v(dout0_10) AT=1450.05n

* CHECK dout0_11 Vdout0_11ck144 = 1.8 time = 1450
.meas tran vdout0_11ck144 FIND v(dout0_11) AT=1450.05n

* CHECK dout0_12 Vdout0_12ck144 = 0 time = 1450
.meas tran vdout0_12ck144 FIND v(dout0_12) AT=1450.05n

* CHECK dout0_13 Vdout0_13ck144 = 1.8 time = 1450
.meas tran vdout0_13ck144 FIND v(dout0_13) AT=1450.05n

* CHECK dout0_14 Vdout0_14ck144 = 1.8 time = 1450
.meas tran vdout0_14ck144 FIND v(dout0_14) AT=1450.05n

* CHECK dout0_15 Vdout0_15ck144 = 1.8 time = 1450
.meas tran vdout0_15ck144 FIND v(dout0_15) AT=1450.05n

* CHECK dout0_16 Vdout0_16ck144 = 0 time = 1450
.meas tran vdout0_16ck144 FIND v(dout0_16) AT=1450.05n

* CHECK dout0_17 Vdout0_17ck144 = 0 time = 1450
.meas tran vdout0_17ck144 FIND v(dout0_17) AT=1450.05n

* CHECK dout0_18 Vdout0_18ck144 = 0 time = 1450
.meas tran vdout0_18ck144 FIND v(dout0_18) AT=1450.05n

* CHECK dout0_19 Vdout0_19ck144 = 1.8 time = 1450
.meas tran vdout0_19ck144 FIND v(dout0_19) AT=1450.05n

* CHECK dout0_20 Vdout0_20ck144 = 0 time = 1450
.meas tran vdout0_20ck144 FIND v(dout0_20) AT=1450.05n

* CHECK dout0_21 Vdout0_21ck144 = 1.8 time = 1450
.meas tran vdout0_21ck144 FIND v(dout0_21) AT=1450.05n

* CHECK dout0_22 Vdout0_22ck144 = 0 time = 1450
.meas tran vdout0_22ck144 FIND v(dout0_22) AT=1450.05n

* CHECK dout0_23 Vdout0_23ck144 = 1.8 time = 1450
.meas tran vdout0_23ck144 FIND v(dout0_23) AT=1450.05n

* CHECK dout0_24 Vdout0_24ck144 = 0 time = 1450
.meas tran vdout0_24ck144 FIND v(dout0_24) AT=1450.05n

* CHECK dout0_25 Vdout0_25ck144 = 1.8 time = 1450
.meas tran vdout0_25ck144 FIND v(dout0_25) AT=1450.05n

* CHECK dout0_26 Vdout0_26ck144 = 0 time = 1450
.meas tran vdout0_26ck144 FIND v(dout0_26) AT=1450.05n

* CHECK dout0_27 Vdout0_27ck144 = 0 time = 1450
.meas tran vdout0_27ck144 FIND v(dout0_27) AT=1450.05n

* CHECK dout0_28 Vdout0_28ck144 = 0 time = 1450
.meas tran vdout0_28ck144 FIND v(dout0_28) AT=1450.05n

* CHECK dout0_29 Vdout0_29ck144 = 0 time = 1450
.meas tran vdout0_29ck144 FIND v(dout0_29) AT=1450.05n

* CHECK dout0_30 Vdout0_30ck144 = 1.8 time = 1450
.meas tran vdout0_30ck144 FIND v(dout0_30) AT=1450.05n

* CHECK dout0_31 Vdout0_31ck144 = 1.8 time = 1450
.meas tran vdout0_31ck144 FIND v(dout0_31) AT=1450.05n

* CHECK dout1_0 Vdout1_0ck145 = 1.8 time = 1460
.meas tran vdout1_0ck145 FIND v(dout1_0) AT=1460.05n

* CHECK dout1_1 Vdout1_1ck145 = 0 time = 1460
.meas tran vdout1_1ck145 FIND v(dout1_1) AT=1460.05n

* CHECK dout1_2 Vdout1_2ck145 = 0 time = 1460
.meas tran vdout1_2ck145 FIND v(dout1_2) AT=1460.05n

* CHECK dout1_3 Vdout1_3ck145 = 0 time = 1460
.meas tran vdout1_3ck145 FIND v(dout1_3) AT=1460.05n

* CHECK dout1_4 Vdout1_4ck145 = 1.8 time = 1460
.meas tran vdout1_4ck145 FIND v(dout1_4) AT=1460.05n

* CHECK dout1_5 Vdout1_5ck145 = 1.8 time = 1460
.meas tran vdout1_5ck145 FIND v(dout1_5) AT=1460.05n

* CHECK dout1_6 Vdout1_6ck145 = 0 time = 1460
.meas tran vdout1_6ck145 FIND v(dout1_6) AT=1460.05n

* CHECK dout1_7 Vdout1_7ck145 = 1.8 time = 1460
.meas tran vdout1_7ck145 FIND v(dout1_7) AT=1460.05n

* CHECK dout1_8 Vdout1_8ck145 = 0 time = 1460
.meas tran vdout1_8ck145 FIND v(dout1_8) AT=1460.05n

* CHECK dout1_9 Vdout1_9ck145 = 0 time = 1460
.meas tran vdout1_9ck145 FIND v(dout1_9) AT=1460.05n

* CHECK dout1_10 Vdout1_10ck145 = 1.8 time = 1460
.meas tran vdout1_10ck145 FIND v(dout1_10) AT=1460.05n

* CHECK dout1_11 Vdout1_11ck145 = 1.8 time = 1460
.meas tran vdout1_11ck145 FIND v(dout1_11) AT=1460.05n

* CHECK dout1_12 Vdout1_12ck145 = 0 time = 1460
.meas tran vdout1_12ck145 FIND v(dout1_12) AT=1460.05n

* CHECK dout1_13 Vdout1_13ck145 = 1.8 time = 1460
.meas tran vdout1_13ck145 FIND v(dout1_13) AT=1460.05n

* CHECK dout1_14 Vdout1_14ck145 = 1.8 time = 1460
.meas tran vdout1_14ck145 FIND v(dout1_14) AT=1460.05n

* CHECK dout1_15 Vdout1_15ck145 = 1.8 time = 1460
.meas tran vdout1_15ck145 FIND v(dout1_15) AT=1460.05n

* CHECK dout1_16 Vdout1_16ck145 = 0 time = 1460
.meas tran vdout1_16ck145 FIND v(dout1_16) AT=1460.05n

* CHECK dout1_17 Vdout1_17ck145 = 0 time = 1460
.meas tran vdout1_17ck145 FIND v(dout1_17) AT=1460.05n

* CHECK dout1_18 Vdout1_18ck145 = 0 time = 1460
.meas tran vdout1_18ck145 FIND v(dout1_18) AT=1460.05n

* CHECK dout1_19 Vdout1_19ck145 = 1.8 time = 1460
.meas tran vdout1_19ck145 FIND v(dout1_19) AT=1460.05n

* CHECK dout1_20 Vdout1_20ck145 = 0 time = 1460
.meas tran vdout1_20ck145 FIND v(dout1_20) AT=1460.05n

* CHECK dout1_21 Vdout1_21ck145 = 1.8 time = 1460
.meas tran vdout1_21ck145 FIND v(dout1_21) AT=1460.05n

* CHECK dout1_22 Vdout1_22ck145 = 0 time = 1460
.meas tran vdout1_22ck145 FIND v(dout1_22) AT=1460.05n

* CHECK dout1_23 Vdout1_23ck145 = 1.8 time = 1460
.meas tran vdout1_23ck145 FIND v(dout1_23) AT=1460.05n

* CHECK dout1_24 Vdout1_24ck145 = 0 time = 1460
.meas tran vdout1_24ck145 FIND v(dout1_24) AT=1460.05n

* CHECK dout1_25 Vdout1_25ck145 = 1.8 time = 1460
.meas tran vdout1_25ck145 FIND v(dout1_25) AT=1460.05n

* CHECK dout1_26 Vdout1_26ck145 = 0 time = 1460
.meas tran vdout1_26ck145 FIND v(dout1_26) AT=1460.05n

* CHECK dout1_27 Vdout1_27ck145 = 0 time = 1460
.meas tran vdout1_27ck145 FIND v(dout1_27) AT=1460.05n

* CHECK dout1_28 Vdout1_28ck145 = 0 time = 1460
.meas tran vdout1_28ck145 FIND v(dout1_28) AT=1460.05n

* CHECK dout1_29 Vdout1_29ck145 = 0 time = 1460
.meas tran vdout1_29ck145 FIND v(dout1_29) AT=1460.05n

* CHECK dout1_30 Vdout1_30ck145 = 1.8 time = 1460
.meas tran vdout1_30ck145 FIND v(dout1_30) AT=1460.05n

* CHECK dout1_31 Vdout1_31ck145 = 1.8 time = 1460
.meas tran vdout1_31ck145 FIND v(dout1_31) AT=1460.05n

* CHECK dout0_0 Vdout0_0ck147 = 1.8 time = 1480
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=1480.05n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 1480
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=1480.05n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 1480
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=1480.05n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 1480
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=1480.05n

* CHECK dout0_4 Vdout0_4ck147 = 1.8 time = 1480
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=1480.05n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 1480
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=1480.05n

* CHECK dout0_6 Vdout0_6ck147 = 1.8 time = 1480
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=1480.05n

* CHECK dout0_7 Vdout0_7ck147 = 1.8 time = 1480
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=1480.05n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 1480
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=1480.05n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 1480
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=1480.05n

* CHECK dout0_10 Vdout0_10ck147 = 0 time = 1480
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=1480.05n

* CHECK dout0_11 Vdout0_11ck147 = 0 time = 1480
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=1480.05n

* CHECK dout0_12 Vdout0_12ck147 = 0 time = 1480
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=1480.05n

* CHECK dout0_13 Vdout0_13ck147 = 0 time = 1480
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=1480.05n

* CHECK dout0_14 Vdout0_14ck147 = 1.8 time = 1480
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=1480.05n

* CHECK dout0_15 Vdout0_15ck147 = 0 time = 1480
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=1480.05n

* CHECK dout0_16 Vdout0_16ck147 = 1.8 time = 1480
.meas tran vdout0_16ck147 FIND v(dout0_16) AT=1480.05n

* CHECK dout0_17 Vdout0_17ck147 = 1.8 time = 1480
.meas tran vdout0_17ck147 FIND v(dout0_17) AT=1480.05n

* CHECK dout0_18 Vdout0_18ck147 = 1.8 time = 1480
.meas tran vdout0_18ck147 FIND v(dout0_18) AT=1480.05n

* CHECK dout0_19 Vdout0_19ck147 = 0 time = 1480
.meas tran vdout0_19ck147 FIND v(dout0_19) AT=1480.05n

* CHECK dout0_20 Vdout0_20ck147 = 0 time = 1480
.meas tran vdout0_20ck147 FIND v(dout0_20) AT=1480.05n

* CHECK dout0_21 Vdout0_21ck147 = 0 time = 1480
.meas tran vdout0_21ck147 FIND v(dout0_21) AT=1480.05n

* CHECK dout0_22 Vdout0_22ck147 = 0 time = 1480
.meas tran vdout0_22ck147 FIND v(dout0_22) AT=1480.05n

* CHECK dout0_23 Vdout0_23ck147 = 1.8 time = 1480
.meas tran vdout0_23ck147 FIND v(dout0_23) AT=1480.05n

* CHECK dout0_24 Vdout0_24ck147 = 0 time = 1480
.meas tran vdout0_24ck147 FIND v(dout0_24) AT=1480.05n

* CHECK dout0_25 Vdout0_25ck147 = 1.8 time = 1480
.meas tran vdout0_25ck147 FIND v(dout0_25) AT=1480.05n

* CHECK dout0_26 Vdout0_26ck147 = 1.8 time = 1480
.meas tran vdout0_26ck147 FIND v(dout0_26) AT=1480.05n

* CHECK dout0_27 Vdout0_27ck147 = 0 time = 1480
.meas tran vdout0_27ck147 FIND v(dout0_27) AT=1480.05n

* CHECK dout0_28 Vdout0_28ck147 = 1.8 time = 1480
.meas tran vdout0_28ck147 FIND v(dout0_28) AT=1480.05n

* CHECK dout0_29 Vdout0_29ck147 = 0 time = 1480
.meas tran vdout0_29ck147 FIND v(dout0_29) AT=1480.05n

* CHECK dout0_30 Vdout0_30ck147 = 1.8 time = 1480
.meas tran vdout0_30ck147 FIND v(dout0_30) AT=1480.05n

* CHECK dout0_31 Vdout0_31ck147 = 0 time = 1480
.meas tran vdout0_31ck147 FIND v(dout0_31) AT=1480.05n

* CHECK dout1_0 Vdout1_0ck147 = 1.8 time = 1480
.meas tran vdout1_0ck147 FIND v(dout1_0) AT=1480.05n

* CHECK dout1_1 Vdout1_1ck147 = 0 time = 1480
.meas tran vdout1_1ck147 FIND v(dout1_1) AT=1480.05n

* CHECK dout1_2 Vdout1_2ck147 = 0 time = 1480
.meas tran vdout1_2ck147 FIND v(dout1_2) AT=1480.05n

* CHECK dout1_3 Vdout1_3ck147 = 0 time = 1480
.meas tran vdout1_3ck147 FIND v(dout1_3) AT=1480.05n

* CHECK dout1_4 Vdout1_4ck147 = 1.8 time = 1480
.meas tran vdout1_4ck147 FIND v(dout1_4) AT=1480.05n

* CHECK dout1_5 Vdout1_5ck147 = 0 time = 1480
.meas tran vdout1_5ck147 FIND v(dout1_5) AT=1480.05n

* CHECK dout1_6 Vdout1_6ck147 = 0 time = 1480
.meas tran vdout1_6ck147 FIND v(dout1_6) AT=1480.05n

* CHECK dout1_7 Vdout1_7ck147 = 0 time = 1480
.meas tran vdout1_7ck147 FIND v(dout1_7) AT=1480.05n

* CHECK dout1_8 Vdout1_8ck147 = 1.8 time = 1480
.meas tran vdout1_8ck147 FIND v(dout1_8) AT=1480.05n

* CHECK dout1_9 Vdout1_9ck147 = 1.8 time = 1480
.meas tran vdout1_9ck147 FIND v(dout1_9) AT=1480.05n

* CHECK dout1_10 Vdout1_10ck147 = 1.8 time = 1480
.meas tran vdout1_10ck147 FIND v(dout1_10) AT=1480.05n

* CHECK dout1_11 Vdout1_11ck147 = 0 time = 1480
.meas tran vdout1_11ck147 FIND v(dout1_11) AT=1480.05n

* CHECK dout1_12 Vdout1_12ck147 = 0 time = 1480
.meas tran vdout1_12ck147 FIND v(dout1_12) AT=1480.05n

* CHECK dout1_13 Vdout1_13ck147 = 0 time = 1480
.meas tran vdout1_13ck147 FIND v(dout1_13) AT=1480.05n

* CHECK dout1_14 Vdout1_14ck147 = 1.8 time = 1480
.meas tran vdout1_14ck147 FIND v(dout1_14) AT=1480.05n

* CHECK dout1_15 Vdout1_15ck147 = 1.8 time = 1480
.meas tran vdout1_15ck147 FIND v(dout1_15) AT=1480.05n

* CHECK dout1_16 Vdout1_16ck147 = 1.8 time = 1480
.meas tran vdout1_16ck147 FIND v(dout1_16) AT=1480.05n

* CHECK dout1_17 Vdout1_17ck147 = 1.8 time = 1480
.meas tran vdout1_17ck147 FIND v(dout1_17) AT=1480.05n

* CHECK dout1_18 Vdout1_18ck147 = 1.8 time = 1480
.meas tran vdout1_18ck147 FIND v(dout1_18) AT=1480.05n

* CHECK dout1_19 Vdout1_19ck147 = 0 time = 1480
.meas tran vdout1_19ck147 FIND v(dout1_19) AT=1480.05n

* CHECK dout1_20 Vdout1_20ck147 = 0 time = 1480
.meas tran vdout1_20ck147 FIND v(dout1_20) AT=1480.05n

* CHECK dout1_21 Vdout1_21ck147 = 0 time = 1480
.meas tran vdout1_21ck147 FIND v(dout1_21) AT=1480.05n

* CHECK dout1_22 Vdout1_22ck147 = 1.8 time = 1480
.meas tran vdout1_22ck147 FIND v(dout1_22) AT=1480.05n

* CHECK dout1_23 Vdout1_23ck147 = 0 time = 1480
.meas tran vdout1_23ck147 FIND v(dout1_23) AT=1480.05n

* CHECK dout1_24 Vdout1_24ck147 = 1.8 time = 1480
.meas tran vdout1_24ck147 FIND v(dout1_24) AT=1480.05n

* CHECK dout1_25 Vdout1_25ck147 = 1.8 time = 1480
.meas tran vdout1_25ck147 FIND v(dout1_25) AT=1480.05n

* CHECK dout1_26 Vdout1_26ck147 = 1.8 time = 1480
.meas tran vdout1_26ck147 FIND v(dout1_26) AT=1480.05n

* CHECK dout1_27 Vdout1_27ck147 = 0 time = 1480
.meas tran vdout1_27ck147 FIND v(dout1_27) AT=1480.05n

* CHECK dout1_28 Vdout1_28ck147 = 0 time = 1480
.meas tran vdout1_28ck147 FIND v(dout1_28) AT=1480.05n

* CHECK dout1_29 Vdout1_29ck147 = 1.8 time = 1480
.meas tran vdout1_29ck147 FIND v(dout1_29) AT=1480.05n

* CHECK dout1_30 Vdout1_30ck147 = 1.8 time = 1480
.meas tran vdout1_30ck147 FIND v(dout1_30) AT=1480.05n

* CHECK dout1_31 Vdout1_31ck147 = 1.8 time = 1480
.meas tran vdout1_31ck147 FIND v(dout1_31) AT=1480.05n

* CHECK dout0_0 Vdout0_0ck148 = 1.8 time = 1490
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=1490.05n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 1490
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=1490.05n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 1490
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=1490.05n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 1490
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=1490.05n

* CHECK dout0_4 Vdout0_4ck148 = 1.8 time = 1490
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=1490.05n

* CHECK dout0_5 Vdout0_5ck148 = 1.8 time = 1490
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=1490.05n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 1490
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=1490.05n

* CHECK dout0_7 Vdout0_7ck148 = 1.8 time = 1490
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=1490.05n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 1490
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=1490.05n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 1490
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=1490.05n

* CHECK dout0_10 Vdout0_10ck148 = 1.8 time = 1490
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=1490.05n

* CHECK dout0_11 Vdout0_11ck148 = 1.8 time = 1490
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=1490.05n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 1490
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=1490.05n

* CHECK dout0_13 Vdout0_13ck148 = 1.8 time = 1490
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=1490.05n

* CHECK dout0_14 Vdout0_14ck148 = 1.8 time = 1490
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=1490.05n

* CHECK dout0_15 Vdout0_15ck148 = 1.8 time = 1490
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=1490.05n

* CHECK dout0_16 Vdout0_16ck148 = 0 time = 1490
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=1490.05n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 1490
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=1490.05n

* CHECK dout0_18 Vdout0_18ck148 = 0 time = 1490
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=1490.05n

* CHECK dout0_19 Vdout0_19ck148 = 1.8 time = 1490
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=1490.05n

* CHECK dout0_20 Vdout0_20ck148 = 0 time = 1490
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=1490.05n

* CHECK dout0_21 Vdout0_21ck148 = 1.8 time = 1490
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=1490.05n

* CHECK dout0_22 Vdout0_22ck148 = 0 time = 1490
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=1490.05n

* CHECK dout0_23 Vdout0_23ck148 = 1.8 time = 1490
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=1490.05n

* CHECK dout0_24 Vdout0_24ck148 = 0 time = 1490
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=1490.05n

* CHECK dout0_25 Vdout0_25ck148 = 1.8 time = 1490
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=1490.05n

* CHECK dout0_26 Vdout0_26ck148 = 0 time = 1490
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=1490.05n

* CHECK dout0_27 Vdout0_27ck148 = 0 time = 1490
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=1490.05n

* CHECK dout0_28 Vdout0_28ck148 = 0 time = 1490
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=1490.05n

* CHECK dout0_29 Vdout0_29ck148 = 0 time = 1490
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=1490.05n

* CHECK dout0_30 Vdout0_30ck148 = 1.8 time = 1490
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=1490.05n

* CHECK dout0_31 Vdout0_31ck148 = 1.8 time = 1490
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=1490.05n

* CHECK dout1_0 Vdout1_0ck148 = 1.8 time = 1490
.meas tran vdout1_0ck148 FIND v(dout1_0) AT=1490.05n

* CHECK dout1_1 Vdout1_1ck148 = 0 time = 1490
.meas tran vdout1_1ck148 FIND v(dout1_1) AT=1490.05n

* CHECK dout1_2 Vdout1_2ck148 = 0 time = 1490
.meas tran vdout1_2ck148 FIND v(dout1_2) AT=1490.05n

* CHECK dout1_3 Vdout1_3ck148 = 0 time = 1490
.meas tran vdout1_3ck148 FIND v(dout1_3) AT=1490.05n

* CHECK dout1_4 Vdout1_4ck148 = 1.8 time = 1490
.meas tran vdout1_4ck148 FIND v(dout1_4) AT=1490.05n

* CHECK dout1_5 Vdout1_5ck148 = 0 time = 1490
.meas tran vdout1_5ck148 FIND v(dout1_5) AT=1490.05n

* CHECK dout1_6 Vdout1_6ck148 = 0 time = 1490
.meas tran vdout1_6ck148 FIND v(dout1_6) AT=1490.05n

* CHECK dout1_7 Vdout1_7ck148 = 0 time = 1490
.meas tran vdout1_7ck148 FIND v(dout1_7) AT=1490.05n

* CHECK dout1_8 Vdout1_8ck148 = 1.8 time = 1490
.meas tran vdout1_8ck148 FIND v(dout1_8) AT=1490.05n

* CHECK dout1_9 Vdout1_9ck148 = 1.8 time = 1490
.meas tran vdout1_9ck148 FIND v(dout1_9) AT=1490.05n

* CHECK dout1_10 Vdout1_10ck148 = 1.8 time = 1490
.meas tran vdout1_10ck148 FIND v(dout1_10) AT=1490.05n

* CHECK dout1_11 Vdout1_11ck148 = 0 time = 1490
.meas tran vdout1_11ck148 FIND v(dout1_11) AT=1490.05n

* CHECK dout1_12 Vdout1_12ck148 = 0 time = 1490
.meas tran vdout1_12ck148 FIND v(dout1_12) AT=1490.05n

* CHECK dout1_13 Vdout1_13ck148 = 0 time = 1490
.meas tran vdout1_13ck148 FIND v(dout1_13) AT=1490.05n

* CHECK dout1_14 Vdout1_14ck148 = 1.8 time = 1490
.meas tran vdout1_14ck148 FIND v(dout1_14) AT=1490.05n

* CHECK dout1_15 Vdout1_15ck148 = 1.8 time = 1490
.meas tran vdout1_15ck148 FIND v(dout1_15) AT=1490.05n

* CHECK dout1_16 Vdout1_16ck148 = 1.8 time = 1490
.meas tran vdout1_16ck148 FIND v(dout1_16) AT=1490.05n

* CHECK dout1_17 Vdout1_17ck148 = 1.8 time = 1490
.meas tran vdout1_17ck148 FIND v(dout1_17) AT=1490.05n

* CHECK dout1_18 Vdout1_18ck148 = 1.8 time = 1490
.meas tran vdout1_18ck148 FIND v(dout1_18) AT=1490.05n

* CHECK dout1_19 Vdout1_19ck148 = 0 time = 1490
.meas tran vdout1_19ck148 FIND v(dout1_19) AT=1490.05n

* CHECK dout1_20 Vdout1_20ck148 = 0 time = 1490
.meas tran vdout1_20ck148 FIND v(dout1_20) AT=1490.05n

* CHECK dout1_21 Vdout1_21ck148 = 0 time = 1490
.meas tran vdout1_21ck148 FIND v(dout1_21) AT=1490.05n

* CHECK dout1_22 Vdout1_22ck148 = 1.8 time = 1490
.meas tran vdout1_22ck148 FIND v(dout1_22) AT=1490.05n

* CHECK dout1_23 Vdout1_23ck148 = 0 time = 1490
.meas tran vdout1_23ck148 FIND v(dout1_23) AT=1490.05n

* CHECK dout1_24 Vdout1_24ck148 = 1.8 time = 1490
.meas tran vdout1_24ck148 FIND v(dout1_24) AT=1490.05n

* CHECK dout1_25 Vdout1_25ck148 = 1.8 time = 1490
.meas tran vdout1_25ck148 FIND v(dout1_25) AT=1490.05n

* CHECK dout1_26 Vdout1_26ck148 = 1.8 time = 1490
.meas tran vdout1_26ck148 FIND v(dout1_26) AT=1490.05n

* CHECK dout1_27 Vdout1_27ck148 = 0 time = 1490
.meas tran vdout1_27ck148 FIND v(dout1_27) AT=1490.05n

* CHECK dout1_28 Vdout1_28ck148 = 0 time = 1490
.meas tran vdout1_28ck148 FIND v(dout1_28) AT=1490.05n

* CHECK dout1_29 Vdout1_29ck148 = 1.8 time = 1490
.meas tran vdout1_29ck148 FIND v(dout1_29) AT=1490.05n

* CHECK dout1_30 Vdout1_30ck148 = 1.8 time = 1490
.meas tran vdout1_30ck148 FIND v(dout1_30) AT=1490.05n

* CHECK dout1_31 Vdout1_31ck148 = 1.8 time = 1490
.meas tran vdout1_31ck148 FIND v(dout1_31) AT=1490.05n

* CHECK dout1_0 Vdout1_0ck149 = 1.8 time = 1500
.meas tran vdout1_0ck149 FIND v(dout1_0) AT=1500.05n

* CHECK dout1_1 Vdout1_1ck149 = 0 time = 1500
.meas tran vdout1_1ck149 FIND v(dout1_1) AT=1500.05n

* CHECK dout1_2 Vdout1_2ck149 = 0 time = 1500
.meas tran vdout1_2ck149 FIND v(dout1_2) AT=1500.05n

* CHECK dout1_3 Vdout1_3ck149 = 0 time = 1500
.meas tran vdout1_3ck149 FIND v(dout1_3) AT=1500.05n

* CHECK dout1_4 Vdout1_4ck149 = 1.8 time = 1500
.meas tran vdout1_4ck149 FIND v(dout1_4) AT=1500.05n

* CHECK dout1_5 Vdout1_5ck149 = 0 time = 1500
.meas tran vdout1_5ck149 FIND v(dout1_5) AT=1500.05n

* CHECK dout1_6 Vdout1_6ck149 = 0 time = 1500
.meas tran vdout1_6ck149 FIND v(dout1_6) AT=1500.05n

* CHECK dout1_7 Vdout1_7ck149 = 0 time = 1500
.meas tran vdout1_7ck149 FIND v(dout1_7) AT=1500.05n

* CHECK dout1_8 Vdout1_8ck149 = 1.8 time = 1500
.meas tran vdout1_8ck149 FIND v(dout1_8) AT=1500.05n

* CHECK dout1_9 Vdout1_9ck149 = 1.8 time = 1500
.meas tran vdout1_9ck149 FIND v(dout1_9) AT=1500.05n

* CHECK dout1_10 Vdout1_10ck149 = 1.8 time = 1500
.meas tran vdout1_10ck149 FIND v(dout1_10) AT=1500.05n

* CHECK dout1_11 Vdout1_11ck149 = 0 time = 1500
.meas tran vdout1_11ck149 FIND v(dout1_11) AT=1500.05n

* CHECK dout1_12 Vdout1_12ck149 = 0 time = 1500
.meas tran vdout1_12ck149 FIND v(dout1_12) AT=1500.05n

* CHECK dout1_13 Vdout1_13ck149 = 0 time = 1500
.meas tran vdout1_13ck149 FIND v(dout1_13) AT=1500.05n

* CHECK dout1_14 Vdout1_14ck149 = 1.8 time = 1500
.meas tran vdout1_14ck149 FIND v(dout1_14) AT=1500.05n

* CHECK dout1_15 Vdout1_15ck149 = 1.8 time = 1500
.meas tran vdout1_15ck149 FIND v(dout1_15) AT=1500.05n

* CHECK dout1_16 Vdout1_16ck149 = 1.8 time = 1500
.meas tran vdout1_16ck149 FIND v(dout1_16) AT=1500.05n

* CHECK dout1_17 Vdout1_17ck149 = 1.8 time = 1500
.meas tran vdout1_17ck149 FIND v(dout1_17) AT=1500.05n

* CHECK dout1_18 Vdout1_18ck149 = 1.8 time = 1500
.meas tran vdout1_18ck149 FIND v(dout1_18) AT=1500.05n

* CHECK dout1_19 Vdout1_19ck149 = 0 time = 1500
.meas tran vdout1_19ck149 FIND v(dout1_19) AT=1500.05n

* CHECK dout1_20 Vdout1_20ck149 = 0 time = 1500
.meas tran vdout1_20ck149 FIND v(dout1_20) AT=1500.05n

* CHECK dout1_21 Vdout1_21ck149 = 0 time = 1500
.meas tran vdout1_21ck149 FIND v(dout1_21) AT=1500.05n

* CHECK dout1_22 Vdout1_22ck149 = 1.8 time = 1500
.meas tran vdout1_22ck149 FIND v(dout1_22) AT=1500.05n

* CHECK dout1_23 Vdout1_23ck149 = 0 time = 1500
.meas tran vdout1_23ck149 FIND v(dout1_23) AT=1500.05n

* CHECK dout1_24 Vdout1_24ck149 = 1.8 time = 1500
.meas tran vdout1_24ck149 FIND v(dout1_24) AT=1500.05n

* CHECK dout1_25 Vdout1_25ck149 = 1.8 time = 1500
.meas tran vdout1_25ck149 FIND v(dout1_25) AT=1500.05n

* CHECK dout1_26 Vdout1_26ck149 = 1.8 time = 1500
.meas tran vdout1_26ck149 FIND v(dout1_26) AT=1500.05n

* CHECK dout1_27 Vdout1_27ck149 = 0 time = 1500
.meas tran vdout1_27ck149 FIND v(dout1_27) AT=1500.05n

* CHECK dout1_28 Vdout1_28ck149 = 0 time = 1500
.meas tran vdout1_28ck149 FIND v(dout1_28) AT=1500.05n

* CHECK dout1_29 Vdout1_29ck149 = 1.8 time = 1500
.meas tran vdout1_29ck149 FIND v(dout1_29) AT=1500.05n

* CHECK dout1_30 Vdout1_30ck149 = 1.8 time = 1500
.meas tran vdout1_30ck149 FIND v(dout1_30) AT=1500.05n

* CHECK dout1_31 Vdout1_31ck149 = 1.8 time = 1500
.meas tran vdout1_31ck149 FIND v(dout1_31) AT=1500.05n

* CHECK dout1_0 Vdout1_0ck150 = 1.8 time = 1510
.meas tran vdout1_0ck150 FIND v(dout1_0) AT=1510.05n

* CHECK dout1_1 Vdout1_1ck150 = 0 time = 1510
.meas tran vdout1_1ck150 FIND v(dout1_1) AT=1510.05n

* CHECK dout1_2 Vdout1_2ck150 = 0 time = 1510
.meas tran vdout1_2ck150 FIND v(dout1_2) AT=1510.05n

* CHECK dout1_3 Vdout1_3ck150 = 0 time = 1510
.meas tran vdout1_3ck150 FIND v(dout1_3) AT=1510.05n

* CHECK dout1_4 Vdout1_4ck150 = 1.8 time = 1510
.meas tran vdout1_4ck150 FIND v(dout1_4) AT=1510.05n

* CHECK dout1_5 Vdout1_5ck150 = 0 time = 1510
.meas tran vdout1_5ck150 FIND v(dout1_5) AT=1510.05n

* CHECK dout1_6 Vdout1_6ck150 = 0 time = 1510
.meas tran vdout1_6ck150 FIND v(dout1_6) AT=1510.05n

* CHECK dout1_7 Vdout1_7ck150 = 0 time = 1510
.meas tran vdout1_7ck150 FIND v(dout1_7) AT=1510.05n

* CHECK dout1_8 Vdout1_8ck150 = 1.8 time = 1510
.meas tran vdout1_8ck150 FIND v(dout1_8) AT=1510.05n

* CHECK dout1_9 Vdout1_9ck150 = 1.8 time = 1510
.meas tran vdout1_9ck150 FIND v(dout1_9) AT=1510.05n

* CHECK dout1_10 Vdout1_10ck150 = 1.8 time = 1510
.meas tran vdout1_10ck150 FIND v(dout1_10) AT=1510.05n

* CHECK dout1_11 Vdout1_11ck150 = 0 time = 1510
.meas tran vdout1_11ck150 FIND v(dout1_11) AT=1510.05n

* CHECK dout1_12 Vdout1_12ck150 = 0 time = 1510
.meas tran vdout1_12ck150 FIND v(dout1_12) AT=1510.05n

* CHECK dout1_13 Vdout1_13ck150 = 0 time = 1510
.meas tran vdout1_13ck150 FIND v(dout1_13) AT=1510.05n

* CHECK dout1_14 Vdout1_14ck150 = 1.8 time = 1510
.meas tran vdout1_14ck150 FIND v(dout1_14) AT=1510.05n

* CHECK dout1_15 Vdout1_15ck150 = 1.8 time = 1510
.meas tran vdout1_15ck150 FIND v(dout1_15) AT=1510.05n

* CHECK dout1_16 Vdout1_16ck150 = 1.8 time = 1510
.meas tran vdout1_16ck150 FIND v(dout1_16) AT=1510.05n

* CHECK dout1_17 Vdout1_17ck150 = 1.8 time = 1510
.meas tran vdout1_17ck150 FIND v(dout1_17) AT=1510.05n

* CHECK dout1_18 Vdout1_18ck150 = 1.8 time = 1510
.meas tran vdout1_18ck150 FIND v(dout1_18) AT=1510.05n

* CHECK dout1_19 Vdout1_19ck150 = 0 time = 1510
.meas tran vdout1_19ck150 FIND v(dout1_19) AT=1510.05n

* CHECK dout1_20 Vdout1_20ck150 = 0 time = 1510
.meas tran vdout1_20ck150 FIND v(dout1_20) AT=1510.05n

* CHECK dout1_21 Vdout1_21ck150 = 0 time = 1510
.meas tran vdout1_21ck150 FIND v(dout1_21) AT=1510.05n

* CHECK dout1_22 Vdout1_22ck150 = 1.8 time = 1510
.meas tran vdout1_22ck150 FIND v(dout1_22) AT=1510.05n

* CHECK dout1_23 Vdout1_23ck150 = 0 time = 1510
.meas tran vdout1_23ck150 FIND v(dout1_23) AT=1510.05n

* CHECK dout1_24 Vdout1_24ck150 = 1.8 time = 1510
.meas tran vdout1_24ck150 FIND v(dout1_24) AT=1510.05n

* CHECK dout1_25 Vdout1_25ck150 = 1.8 time = 1510
.meas tran vdout1_25ck150 FIND v(dout1_25) AT=1510.05n

* CHECK dout1_26 Vdout1_26ck150 = 1.8 time = 1510
.meas tran vdout1_26ck150 FIND v(dout1_26) AT=1510.05n

* CHECK dout1_27 Vdout1_27ck150 = 0 time = 1510
.meas tran vdout1_27ck150 FIND v(dout1_27) AT=1510.05n

* CHECK dout1_28 Vdout1_28ck150 = 0 time = 1510
.meas tran vdout1_28ck150 FIND v(dout1_28) AT=1510.05n

* CHECK dout1_29 Vdout1_29ck150 = 1.8 time = 1510
.meas tran vdout1_29ck150 FIND v(dout1_29) AT=1510.05n

* CHECK dout1_30 Vdout1_30ck150 = 1.8 time = 1510
.meas tran vdout1_30ck150 FIND v(dout1_30) AT=1510.05n

* CHECK dout1_31 Vdout1_31ck150 = 1.8 time = 1510
.meas tran vdout1_31ck150 FIND v(dout1_31) AT=1510.05n

* CHECK dout0_0 Vdout0_0ck151 = 1.8 time = 1520
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=1520.05n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 1520
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=1520.05n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 1520
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=1520.05n

* CHECK dout0_3 Vdout0_3ck151 = 1.8 time = 1520
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=1520.05n

* CHECK dout0_4 Vdout0_4ck151 = 1.8 time = 1520
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=1520.05n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 1520
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=1520.05n

* CHECK dout0_6 Vdout0_6ck151 = 1.8 time = 1520
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=1520.05n

* CHECK dout0_7 Vdout0_7ck151 = 1.8 time = 1520
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=1520.05n

* CHECK dout0_8 Vdout0_8ck151 = 0 time = 1520
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=1520.05n

* CHECK dout0_9 Vdout0_9ck151 = 1.8 time = 1520
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=1520.05n

* CHECK dout0_10 Vdout0_10ck151 = 0 time = 1520
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=1520.05n

* CHECK dout0_11 Vdout0_11ck151 = 0 time = 1520
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=1520.05n

* CHECK dout0_12 Vdout0_12ck151 = 0 time = 1520
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=1520.05n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 1520
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=1520.05n

* CHECK dout0_14 Vdout0_14ck151 = 1.8 time = 1520
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=1520.05n

* CHECK dout0_15 Vdout0_15ck151 = 0 time = 1520
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=1520.05n

* CHECK dout0_16 Vdout0_16ck151 = 1.8 time = 1520
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=1520.05n

* CHECK dout0_17 Vdout0_17ck151 = 1.8 time = 1520
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=1520.05n

* CHECK dout0_18 Vdout0_18ck151 = 1.8 time = 1520
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=1520.05n

* CHECK dout0_19 Vdout0_19ck151 = 0 time = 1520
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=1520.05n

* CHECK dout0_20 Vdout0_20ck151 = 0 time = 1520
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=1520.05n

* CHECK dout0_21 Vdout0_21ck151 = 0 time = 1520
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=1520.05n

* CHECK dout0_22 Vdout0_22ck151 = 0 time = 1520
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=1520.05n

* CHECK dout0_23 Vdout0_23ck151 = 1.8 time = 1520
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=1520.05n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 1520
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=1520.05n

* CHECK dout0_25 Vdout0_25ck151 = 1.8 time = 1520
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=1520.05n

* CHECK dout0_26 Vdout0_26ck151 = 1.8 time = 1520
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=1520.05n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 1520
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=1520.05n

* CHECK dout0_28 Vdout0_28ck151 = 1.8 time = 1520
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=1520.05n

* CHECK dout0_29 Vdout0_29ck151 = 0 time = 1520
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=1520.05n

* CHECK dout0_30 Vdout0_30ck151 = 1.8 time = 1520
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=1520.05n

* CHECK dout0_31 Vdout0_31ck151 = 0 time = 1520
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=1520.05n

* CHECK dout1_0 Vdout1_0ck151 = 1.8 time = 1520
.meas tran vdout1_0ck151 FIND v(dout1_0) AT=1520.05n

* CHECK dout1_1 Vdout1_1ck151 = 0 time = 1520
.meas tran vdout1_1ck151 FIND v(dout1_1) AT=1520.05n

* CHECK dout1_2 Vdout1_2ck151 = 0 time = 1520
.meas tran vdout1_2ck151 FIND v(dout1_2) AT=1520.05n

* CHECK dout1_3 Vdout1_3ck151 = 0 time = 1520
.meas tran vdout1_3ck151 FIND v(dout1_3) AT=1520.05n

* CHECK dout1_4 Vdout1_4ck151 = 1.8 time = 1520
.meas tran vdout1_4ck151 FIND v(dout1_4) AT=1520.05n

* CHECK dout1_5 Vdout1_5ck151 = 0 time = 1520
.meas tran vdout1_5ck151 FIND v(dout1_5) AT=1520.05n

* CHECK dout1_6 Vdout1_6ck151 = 0 time = 1520
.meas tran vdout1_6ck151 FIND v(dout1_6) AT=1520.05n

* CHECK dout1_7 Vdout1_7ck151 = 0 time = 1520
.meas tran vdout1_7ck151 FIND v(dout1_7) AT=1520.05n

* CHECK dout1_8 Vdout1_8ck151 = 1.8 time = 1520
.meas tran vdout1_8ck151 FIND v(dout1_8) AT=1520.05n

* CHECK dout1_9 Vdout1_9ck151 = 1.8 time = 1520
.meas tran vdout1_9ck151 FIND v(dout1_9) AT=1520.05n

* CHECK dout1_10 Vdout1_10ck151 = 1.8 time = 1520
.meas tran vdout1_10ck151 FIND v(dout1_10) AT=1520.05n

* CHECK dout1_11 Vdout1_11ck151 = 0 time = 1520
.meas tran vdout1_11ck151 FIND v(dout1_11) AT=1520.05n

* CHECK dout1_12 Vdout1_12ck151 = 0 time = 1520
.meas tran vdout1_12ck151 FIND v(dout1_12) AT=1520.05n

* CHECK dout1_13 Vdout1_13ck151 = 0 time = 1520
.meas tran vdout1_13ck151 FIND v(dout1_13) AT=1520.05n

* CHECK dout1_14 Vdout1_14ck151 = 1.8 time = 1520
.meas tran vdout1_14ck151 FIND v(dout1_14) AT=1520.05n

* CHECK dout1_15 Vdout1_15ck151 = 1.8 time = 1520
.meas tran vdout1_15ck151 FIND v(dout1_15) AT=1520.05n

* CHECK dout1_16 Vdout1_16ck151 = 1.8 time = 1520
.meas tran vdout1_16ck151 FIND v(dout1_16) AT=1520.05n

* CHECK dout1_17 Vdout1_17ck151 = 1.8 time = 1520
.meas tran vdout1_17ck151 FIND v(dout1_17) AT=1520.05n

* CHECK dout1_18 Vdout1_18ck151 = 1.8 time = 1520
.meas tran vdout1_18ck151 FIND v(dout1_18) AT=1520.05n

* CHECK dout1_19 Vdout1_19ck151 = 0 time = 1520
.meas tran vdout1_19ck151 FIND v(dout1_19) AT=1520.05n

* CHECK dout1_20 Vdout1_20ck151 = 0 time = 1520
.meas tran vdout1_20ck151 FIND v(dout1_20) AT=1520.05n

* CHECK dout1_21 Vdout1_21ck151 = 0 time = 1520
.meas tran vdout1_21ck151 FIND v(dout1_21) AT=1520.05n

* CHECK dout1_22 Vdout1_22ck151 = 1.8 time = 1520
.meas tran vdout1_22ck151 FIND v(dout1_22) AT=1520.05n

* CHECK dout1_23 Vdout1_23ck151 = 0 time = 1520
.meas tran vdout1_23ck151 FIND v(dout1_23) AT=1520.05n

* CHECK dout1_24 Vdout1_24ck151 = 1.8 time = 1520
.meas tran vdout1_24ck151 FIND v(dout1_24) AT=1520.05n

* CHECK dout1_25 Vdout1_25ck151 = 1.8 time = 1520
.meas tran vdout1_25ck151 FIND v(dout1_25) AT=1520.05n

* CHECK dout1_26 Vdout1_26ck151 = 1.8 time = 1520
.meas tran vdout1_26ck151 FIND v(dout1_26) AT=1520.05n

* CHECK dout1_27 Vdout1_27ck151 = 0 time = 1520
.meas tran vdout1_27ck151 FIND v(dout1_27) AT=1520.05n

* CHECK dout1_28 Vdout1_28ck151 = 0 time = 1520
.meas tran vdout1_28ck151 FIND v(dout1_28) AT=1520.05n

* CHECK dout1_29 Vdout1_29ck151 = 1.8 time = 1520
.meas tran vdout1_29ck151 FIND v(dout1_29) AT=1520.05n

* CHECK dout1_30 Vdout1_30ck151 = 1.8 time = 1520
.meas tran vdout1_30ck151 FIND v(dout1_30) AT=1520.05n

* CHECK dout1_31 Vdout1_31ck151 = 1.8 time = 1520
.meas tran vdout1_31ck151 FIND v(dout1_31) AT=1520.05n

* CHECK dout0_0 Vdout0_0ck152 = 1.8 time = 1530
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=1530.05n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 1530
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=1530.05n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 1530
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=1530.05n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 1530
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=1530.05n

* CHECK dout0_4 Vdout0_4ck152 = 1.8 time = 1530
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=1530.05n

* CHECK dout0_5 Vdout0_5ck152 = 0 time = 1530
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=1530.05n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 1530
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=1530.05n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 1530
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=1530.05n

* CHECK dout0_8 Vdout0_8ck152 = 1.8 time = 1530
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=1530.05n

* CHECK dout0_9 Vdout0_9ck152 = 1.8 time = 1530
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=1530.05n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 1530
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=1530.05n

* CHECK dout0_11 Vdout0_11ck152 = 0 time = 1530
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=1530.05n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 1530
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=1530.05n

* CHECK dout0_13 Vdout0_13ck152 = 0 time = 1530
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=1530.05n

* CHECK dout0_14 Vdout0_14ck152 = 1.8 time = 1530
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=1530.05n

* CHECK dout0_15 Vdout0_15ck152 = 1.8 time = 1530
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=1530.05n

* CHECK dout0_16 Vdout0_16ck152 = 1.8 time = 1530
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=1530.05n

* CHECK dout0_17 Vdout0_17ck152 = 1.8 time = 1530
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=1530.05n

* CHECK dout0_18 Vdout0_18ck152 = 1.8 time = 1530
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=1530.05n

* CHECK dout0_19 Vdout0_19ck152 = 0 time = 1530
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=1530.05n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 1530
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=1530.05n

* CHECK dout0_21 Vdout0_21ck152 = 0 time = 1530
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=1530.05n

* CHECK dout0_22 Vdout0_22ck152 = 1.8 time = 1530
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=1530.05n

* CHECK dout0_23 Vdout0_23ck152 = 0 time = 1530
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=1530.05n

* CHECK dout0_24 Vdout0_24ck152 = 1.8 time = 1530
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=1530.05n

* CHECK dout0_25 Vdout0_25ck152 = 1.8 time = 1530
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=1530.05n

* CHECK dout0_26 Vdout0_26ck152 = 1.8 time = 1530
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=1530.05n

* CHECK dout0_27 Vdout0_27ck152 = 0 time = 1530
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=1530.05n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 1530
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=1530.05n

* CHECK dout0_29 Vdout0_29ck152 = 1.8 time = 1530
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=1530.05n

* CHECK dout0_30 Vdout0_30ck152 = 1.8 time = 1530
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=1530.05n

* CHECK dout0_31 Vdout0_31ck152 = 1.8 time = 1530
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=1530.05n

* CHECK dout0_0 Vdout0_0ck153 = 0 time = 1540
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=1540.05n

* CHECK dout0_1 Vdout0_1ck153 = 1.8 time = 1540
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=1540.05n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 1540
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=1540.05n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 1540
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=1540.05n

* CHECK dout0_4 Vdout0_4ck153 = 0 time = 1540
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=1540.05n

* CHECK dout0_5 Vdout0_5ck153 = 1.8 time = 1540
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=1540.05n

* CHECK dout0_6 Vdout0_6ck153 = 0 time = 1540
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=1540.05n

* CHECK dout0_7 Vdout0_7ck153 = 0 time = 1540
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=1540.05n

* CHECK dout0_8 Vdout0_8ck153 = 1.8 time = 1540
.meas tran vdout0_8ck153 FIND v(dout0_8) AT=1540.05n

* CHECK dout0_9 Vdout0_9ck153 = 1.8 time = 1540
.meas tran vdout0_9ck153 FIND v(dout0_9) AT=1540.05n

* CHECK dout0_10 Vdout0_10ck153 = 0 time = 1540
.meas tran vdout0_10ck153 FIND v(dout0_10) AT=1540.05n

* CHECK dout0_11 Vdout0_11ck153 = 0 time = 1540
.meas tran vdout0_11ck153 FIND v(dout0_11) AT=1540.05n

* CHECK dout0_12 Vdout0_12ck153 = 1.8 time = 1540
.meas tran vdout0_12ck153 FIND v(dout0_12) AT=1540.05n

* CHECK dout0_13 Vdout0_13ck153 = 1.8 time = 1540
.meas tran vdout0_13ck153 FIND v(dout0_13) AT=1540.05n

* CHECK dout0_14 Vdout0_14ck153 = 1.8 time = 1540
.meas tran vdout0_14ck153 FIND v(dout0_14) AT=1540.05n

* CHECK dout0_15 Vdout0_15ck153 = 0 time = 1540
.meas tran vdout0_15ck153 FIND v(dout0_15) AT=1540.05n

* CHECK dout0_16 Vdout0_16ck153 = 1.8 time = 1540
.meas tran vdout0_16ck153 FIND v(dout0_16) AT=1540.05n

* CHECK dout0_17 Vdout0_17ck153 = 0 time = 1540
.meas tran vdout0_17ck153 FIND v(dout0_17) AT=1540.05n

* CHECK dout0_18 Vdout0_18ck153 = 0 time = 1540
.meas tran vdout0_18ck153 FIND v(dout0_18) AT=1540.05n

* CHECK dout0_19 Vdout0_19ck153 = 1.8 time = 1540
.meas tran vdout0_19ck153 FIND v(dout0_19) AT=1540.05n

* CHECK dout0_20 Vdout0_20ck153 = 1.8 time = 1540
.meas tran vdout0_20ck153 FIND v(dout0_20) AT=1540.05n

* CHECK dout0_21 Vdout0_21ck153 = 0 time = 1540
.meas tran vdout0_21ck153 FIND v(dout0_21) AT=1540.05n

* CHECK dout0_22 Vdout0_22ck153 = 0 time = 1540
.meas tran vdout0_22ck153 FIND v(dout0_22) AT=1540.05n

* CHECK dout0_23 Vdout0_23ck153 = 1.8 time = 1540
.meas tran vdout0_23ck153 FIND v(dout0_23) AT=1540.05n

* CHECK dout0_24 Vdout0_24ck153 = 1.8 time = 1540
.meas tran vdout0_24ck153 FIND v(dout0_24) AT=1540.05n

* CHECK dout0_25 Vdout0_25ck153 = 1.8 time = 1540
.meas tran vdout0_25ck153 FIND v(dout0_25) AT=1540.05n

* CHECK dout0_26 Vdout0_26ck153 = 0 time = 1540
.meas tran vdout0_26ck153 FIND v(dout0_26) AT=1540.05n

* CHECK dout0_27 Vdout0_27ck153 = 0 time = 1540
.meas tran vdout0_27ck153 FIND v(dout0_27) AT=1540.05n

* CHECK dout0_28 Vdout0_28ck153 = 0 time = 1540
.meas tran vdout0_28ck153 FIND v(dout0_28) AT=1540.05n

* CHECK dout0_29 Vdout0_29ck153 = 0 time = 1540
.meas tran vdout0_29ck153 FIND v(dout0_29) AT=1540.05n

* CHECK dout0_30 Vdout0_30ck153 = 1.8 time = 1540
.meas tran vdout0_30ck153 FIND v(dout0_30) AT=1540.05n

* CHECK dout0_31 Vdout0_31ck153 = 1.8 time = 1540
.meas tran vdout0_31ck153 FIND v(dout0_31) AT=1540.05n

* CHECK dout1_0 Vdout1_0ck153 = 0 time = 1540
.meas tran vdout1_0ck153 FIND v(dout1_0) AT=1540.05n

* CHECK dout1_1 Vdout1_1ck153 = 1.8 time = 1540
.meas tran vdout1_1ck153 FIND v(dout1_1) AT=1540.05n

* CHECK dout1_2 Vdout1_2ck153 = 0 time = 1540
.meas tran vdout1_2ck153 FIND v(dout1_2) AT=1540.05n

* CHECK dout1_3 Vdout1_3ck153 = 0 time = 1540
.meas tran vdout1_3ck153 FIND v(dout1_3) AT=1540.05n

* CHECK dout1_4 Vdout1_4ck153 = 0 time = 1540
.meas tran vdout1_4ck153 FIND v(dout1_4) AT=1540.05n

* CHECK dout1_5 Vdout1_5ck153 = 1.8 time = 1540
.meas tran vdout1_5ck153 FIND v(dout1_5) AT=1540.05n

* CHECK dout1_6 Vdout1_6ck153 = 0 time = 1540
.meas tran vdout1_6ck153 FIND v(dout1_6) AT=1540.05n

* CHECK dout1_7 Vdout1_7ck153 = 0 time = 1540
.meas tran vdout1_7ck153 FIND v(dout1_7) AT=1540.05n

* CHECK dout1_8 Vdout1_8ck153 = 1.8 time = 1540
.meas tran vdout1_8ck153 FIND v(dout1_8) AT=1540.05n

* CHECK dout1_9 Vdout1_9ck153 = 1.8 time = 1540
.meas tran vdout1_9ck153 FIND v(dout1_9) AT=1540.05n

* CHECK dout1_10 Vdout1_10ck153 = 0 time = 1540
.meas tran vdout1_10ck153 FIND v(dout1_10) AT=1540.05n

* CHECK dout1_11 Vdout1_11ck153 = 0 time = 1540
.meas tran vdout1_11ck153 FIND v(dout1_11) AT=1540.05n

* CHECK dout1_12 Vdout1_12ck153 = 1.8 time = 1540
.meas tran vdout1_12ck153 FIND v(dout1_12) AT=1540.05n

* CHECK dout1_13 Vdout1_13ck153 = 1.8 time = 1540
.meas tran vdout1_13ck153 FIND v(dout1_13) AT=1540.05n

* CHECK dout1_14 Vdout1_14ck153 = 1.8 time = 1540
.meas tran vdout1_14ck153 FIND v(dout1_14) AT=1540.05n

* CHECK dout1_15 Vdout1_15ck153 = 0 time = 1540
.meas tran vdout1_15ck153 FIND v(dout1_15) AT=1540.05n

* CHECK dout1_16 Vdout1_16ck153 = 1.8 time = 1540
.meas tran vdout1_16ck153 FIND v(dout1_16) AT=1540.05n

* CHECK dout1_17 Vdout1_17ck153 = 0 time = 1540
.meas tran vdout1_17ck153 FIND v(dout1_17) AT=1540.05n

* CHECK dout1_18 Vdout1_18ck153 = 0 time = 1540
.meas tran vdout1_18ck153 FIND v(dout1_18) AT=1540.05n

* CHECK dout1_19 Vdout1_19ck153 = 1.8 time = 1540
.meas tran vdout1_19ck153 FIND v(dout1_19) AT=1540.05n

* CHECK dout1_20 Vdout1_20ck153 = 1.8 time = 1540
.meas tran vdout1_20ck153 FIND v(dout1_20) AT=1540.05n

* CHECK dout1_21 Vdout1_21ck153 = 0 time = 1540
.meas tran vdout1_21ck153 FIND v(dout1_21) AT=1540.05n

* CHECK dout1_22 Vdout1_22ck153 = 0 time = 1540
.meas tran vdout1_22ck153 FIND v(dout1_22) AT=1540.05n

* CHECK dout1_23 Vdout1_23ck153 = 1.8 time = 1540
.meas tran vdout1_23ck153 FIND v(dout1_23) AT=1540.05n

* CHECK dout1_24 Vdout1_24ck153 = 1.8 time = 1540
.meas tran vdout1_24ck153 FIND v(dout1_24) AT=1540.05n

* CHECK dout1_25 Vdout1_25ck153 = 1.8 time = 1540
.meas tran vdout1_25ck153 FIND v(dout1_25) AT=1540.05n

* CHECK dout1_26 Vdout1_26ck153 = 0 time = 1540
.meas tran vdout1_26ck153 FIND v(dout1_26) AT=1540.05n

* CHECK dout1_27 Vdout1_27ck153 = 0 time = 1540
.meas tran vdout1_27ck153 FIND v(dout1_27) AT=1540.05n

* CHECK dout1_28 Vdout1_28ck153 = 0 time = 1540
.meas tran vdout1_28ck153 FIND v(dout1_28) AT=1540.05n

* CHECK dout1_29 Vdout1_29ck153 = 0 time = 1540
.meas tran vdout1_29ck153 FIND v(dout1_29) AT=1540.05n

* CHECK dout1_30 Vdout1_30ck153 = 1.8 time = 1540
.meas tran vdout1_30ck153 FIND v(dout1_30) AT=1540.05n

* CHECK dout1_31 Vdout1_31ck153 = 1.8 time = 1540
.meas tran vdout1_31ck153 FIND v(dout1_31) AT=1540.05n

* CHECK dout0_0 Vdout0_0ck156 = 1.8 time = 1570
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=1570.05n

* CHECK dout0_1 Vdout0_1ck156 = 0 time = 1570
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=1570.05n

* CHECK dout0_2 Vdout0_2ck156 = 0 time = 1570
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=1570.05n

* CHECK dout0_3 Vdout0_3ck156 = 1.8 time = 1570
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=1570.05n

* CHECK dout0_4 Vdout0_4ck156 = 1.8 time = 1570
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=1570.05n

* CHECK dout0_5 Vdout0_5ck156 = 0 time = 1570
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=1570.05n

* CHECK dout0_6 Vdout0_6ck156 = 1.8 time = 1570
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=1570.05n

* CHECK dout0_7 Vdout0_7ck156 = 1.8 time = 1570
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=1570.05n

* CHECK dout0_8 Vdout0_8ck156 = 0 time = 1570
.meas tran vdout0_8ck156 FIND v(dout0_8) AT=1570.05n

* CHECK dout0_9 Vdout0_9ck156 = 1.8 time = 1570
.meas tran vdout0_9ck156 FIND v(dout0_9) AT=1570.05n

* CHECK dout0_10 Vdout0_10ck156 = 0 time = 1570
.meas tran vdout0_10ck156 FIND v(dout0_10) AT=1570.05n

* CHECK dout0_11 Vdout0_11ck156 = 0 time = 1570
.meas tran vdout0_11ck156 FIND v(dout0_11) AT=1570.05n

* CHECK dout0_12 Vdout0_12ck156 = 0 time = 1570
.meas tran vdout0_12ck156 FIND v(dout0_12) AT=1570.05n

* CHECK dout0_13 Vdout0_13ck156 = 0 time = 1570
.meas tran vdout0_13ck156 FIND v(dout0_13) AT=1570.05n

* CHECK dout0_14 Vdout0_14ck156 = 1.8 time = 1570
.meas tran vdout0_14ck156 FIND v(dout0_14) AT=1570.05n

* CHECK dout0_15 Vdout0_15ck156 = 0 time = 1570
.meas tran vdout0_15ck156 FIND v(dout0_15) AT=1570.05n

* CHECK dout0_16 Vdout0_16ck156 = 1.8 time = 1570
.meas tran vdout0_16ck156 FIND v(dout0_16) AT=1570.05n

* CHECK dout0_17 Vdout0_17ck156 = 1.8 time = 1570
.meas tran vdout0_17ck156 FIND v(dout0_17) AT=1570.05n

* CHECK dout0_18 Vdout0_18ck156 = 1.8 time = 1570
.meas tran vdout0_18ck156 FIND v(dout0_18) AT=1570.05n

* CHECK dout0_19 Vdout0_19ck156 = 0 time = 1570
.meas tran vdout0_19ck156 FIND v(dout0_19) AT=1570.05n

* CHECK dout0_20 Vdout0_20ck156 = 0 time = 1570
.meas tran vdout0_20ck156 FIND v(dout0_20) AT=1570.05n

* CHECK dout0_21 Vdout0_21ck156 = 0 time = 1570
.meas tran vdout0_21ck156 FIND v(dout0_21) AT=1570.05n

* CHECK dout0_22 Vdout0_22ck156 = 0 time = 1570
.meas tran vdout0_22ck156 FIND v(dout0_22) AT=1570.05n

* CHECK dout0_23 Vdout0_23ck156 = 1.8 time = 1570
.meas tran vdout0_23ck156 FIND v(dout0_23) AT=1570.05n

* CHECK dout0_24 Vdout0_24ck156 = 0 time = 1570
.meas tran vdout0_24ck156 FIND v(dout0_24) AT=1570.05n

* CHECK dout0_25 Vdout0_25ck156 = 1.8 time = 1570
.meas tran vdout0_25ck156 FIND v(dout0_25) AT=1570.05n

* CHECK dout0_26 Vdout0_26ck156 = 1.8 time = 1570
.meas tran vdout0_26ck156 FIND v(dout0_26) AT=1570.05n

* CHECK dout0_27 Vdout0_27ck156 = 0 time = 1570
.meas tran vdout0_27ck156 FIND v(dout0_27) AT=1570.05n

* CHECK dout0_28 Vdout0_28ck156 = 1.8 time = 1570
.meas tran vdout0_28ck156 FIND v(dout0_28) AT=1570.05n

* CHECK dout0_29 Vdout0_29ck156 = 0 time = 1570
.meas tran vdout0_29ck156 FIND v(dout0_29) AT=1570.05n

* CHECK dout0_30 Vdout0_30ck156 = 1.8 time = 1570
.meas tran vdout0_30ck156 FIND v(dout0_30) AT=1570.05n

* CHECK dout0_31 Vdout0_31ck156 = 0 time = 1570
.meas tran vdout0_31ck156 FIND v(dout0_31) AT=1570.05n

* CHECK dout0_0 Vdout0_0ck157 = 1.8 time = 1580
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=1580.05n

* CHECK dout0_1 Vdout0_1ck157 = 0 time = 1580
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=1580.05n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 1580
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=1580.05n

* CHECK dout0_3 Vdout0_3ck157 = 0 time = 1580
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=1580.05n

* CHECK dout0_4 Vdout0_4ck157 = 1.8 time = 1580
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=1580.05n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 1580
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=1580.05n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 1580
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=1580.05n

* CHECK dout0_7 Vdout0_7ck157 = 0 time = 1580
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=1580.05n

* CHECK dout0_8 Vdout0_8ck157 = 1.8 time = 1580
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=1580.05n

* CHECK dout0_9 Vdout0_9ck157 = 1.8 time = 1580
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=1580.05n

* CHECK dout0_10 Vdout0_10ck157 = 1.8 time = 1580
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=1580.05n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 1580
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=1580.05n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 1580
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=1580.05n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 1580
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=1580.05n

* CHECK dout0_14 Vdout0_14ck157 = 1.8 time = 1580
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=1580.05n

* CHECK dout0_15 Vdout0_15ck157 = 1.8 time = 1580
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=1580.05n

* CHECK dout0_16 Vdout0_16ck157 = 1.8 time = 1580
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=1580.05n

* CHECK dout0_17 Vdout0_17ck157 = 1.8 time = 1580
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=1580.05n

* CHECK dout0_18 Vdout0_18ck157 = 1.8 time = 1580
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=1580.05n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 1580
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=1580.05n

* CHECK dout0_20 Vdout0_20ck157 = 0 time = 1580
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=1580.05n

* CHECK dout0_21 Vdout0_21ck157 = 0 time = 1580
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=1580.05n

* CHECK dout0_22 Vdout0_22ck157 = 1.8 time = 1580
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=1580.05n

* CHECK dout0_23 Vdout0_23ck157 = 0 time = 1580
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=1580.05n

* CHECK dout0_24 Vdout0_24ck157 = 1.8 time = 1580
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=1580.05n

* CHECK dout0_25 Vdout0_25ck157 = 1.8 time = 1580
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=1580.05n

* CHECK dout0_26 Vdout0_26ck157 = 1.8 time = 1580
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=1580.05n

* CHECK dout0_27 Vdout0_27ck157 = 0 time = 1580
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=1580.05n

* CHECK dout0_28 Vdout0_28ck157 = 0 time = 1580
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=1580.05n

* CHECK dout0_29 Vdout0_29ck157 = 1.8 time = 1580
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=1580.05n

* CHECK dout0_30 Vdout0_30ck157 = 1.8 time = 1580
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=1580.05n

* CHECK dout0_31 Vdout0_31ck157 = 1.8 time = 1580
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=1580.05n

* CHECK dout1_0 Vdout1_0ck157 = 1.8 time = 1580
.meas tran vdout1_0ck157 FIND v(dout1_0) AT=1580.05n

* CHECK dout1_1 Vdout1_1ck157 = 0 time = 1580
.meas tran vdout1_1ck157 FIND v(dout1_1) AT=1580.05n

* CHECK dout1_2 Vdout1_2ck157 = 0 time = 1580
.meas tran vdout1_2ck157 FIND v(dout1_2) AT=1580.05n

* CHECK dout1_3 Vdout1_3ck157 = 1.8 time = 1580
.meas tran vdout1_3ck157 FIND v(dout1_3) AT=1580.05n

* CHECK dout1_4 Vdout1_4ck157 = 1.8 time = 1580
.meas tran vdout1_4ck157 FIND v(dout1_4) AT=1580.05n

* CHECK dout1_5 Vdout1_5ck157 = 0 time = 1580
.meas tran vdout1_5ck157 FIND v(dout1_5) AT=1580.05n

* CHECK dout1_6 Vdout1_6ck157 = 1.8 time = 1580
.meas tran vdout1_6ck157 FIND v(dout1_6) AT=1580.05n

* CHECK dout1_7 Vdout1_7ck157 = 1.8 time = 1580
.meas tran vdout1_7ck157 FIND v(dout1_7) AT=1580.05n

* CHECK dout1_8 Vdout1_8ck157 = 0 time = 1580
.meas tran vdout1_8ck157 FIND v(dout1_8) AT=1580.05n

* CHECK dout1_9 Vdout1_9ck157 = 1.8 time = 1580
.meas tran vdout1_9ck157 FIND v(dout1_9) AT=1580.05n

* CHECK dout1_10 Vdout1_10ck157 = 0 time = 1580
.meas tran vdout1_10ck157 FIND v(dout1_10) AT=1580.05n

* CHECK dout1_11 Vdout1_11ck157 = 0 time = 1580
.meas tran vdout1_11ck157 FIND v(dout1_11) AT=1580.05n

* CHECK dout1_12 Vdout1_12ck157 = 0 time = 1580
.meas tran vdout1_12ck157 FIND v(dout1_12) AT=1580.05n

* CHECK dout1_13 Vdout1_13ck157 = 0 time = 1580
.meas tran vdout1_13ck157 FIND v(dout1_13) AT=1580.05n

* CHECK dout1_14 Vdout1_14ck157 = 1.8 time = 1580
.meas tran vdout1_14ck157 FIND v(dout1_14) AT=1580.05n

* CHECK dout1_15 Vdout1_15ck157 = 0 time = 1580
.meas tran vdout1_15ck157 FIND v(dout1_15) AT=1580.05n

* CHECK dout1_16 Vdout1_16ck157 = 1.8 time = 1580
.meas tran vdout1_16ck157 FIND v(dout1_16) AT=1580.05n

* CHECK dout1_17 Vdout1_17ck157 = 1.8 time = 1580
.meas tran vdout1_17ck157 FIND v(dout1_17) AT=1580.05n

* CHECK dout1_18 Vdout1_18ck157 = 1.8 time = 1580
.meas tran vdout1_18ck157 FIND v(dout1_18) AT=1580.05n

* CHECK dout1_19 Vdout1_19ck157 = 0 time = 1580
.meas tran vdout1_19ck157 FIND v(dout1_19) AT=1580.05n

* CHECK dout1_20 Vdout1_20ck157 = 0 time = 1580
.meas tran vdout1_20ck157 FIND v(dout1_20) AT=1580.05n

* CHECK dout1_21 Vdout1_21ck157 = 0 time = 1580
.meas tran vdout1_21ck157 FIND v(dout1_21) AT=1580.05n

* CHECK dout1_22 Vdout1_22ck157 = 0 time = 1580
.meas tran vdout1_22ck157 FIND v(dout1_22) AT=1580.05n

* CHECK dout1_23 Vdout1_23ck157 = 1.8 time = 1580
.meas tran vdout1_23ck157 FIND v(dout1_23) AT=1580.05n

* CHECK dout1_24 Vdout1_24ck157 = 0 time = 1580
.meas tran vdout1_24ck157 FIND v(dout1_24) AT=1580.05n

* CHECK dout1_25 Vdout1_25ck157 = 1.8 time = 1580
.meas tran vdout1_25ck157 FIND v(dout1_25) AT=1580.05n

* CHECK dout1_26 Vdout1_26ck157 = 1.8 time = 1580
.meas tran vdout1_26ck157 FIND v(dout1_26) AT=1580.05n

* CHECK dout1_27 Vdout1_27ck157 = 0 time = 1580
.meas tran vdout1_27ck157 FIND v(dout1_27) AT=1580.05n

* CHECK dout1_28 Vdout1_28ck157 = 1.8 time = 1580
.meas tran vdout1_28ck157 FIND v(dout1_28) AT=1580.05n

* CHECK dout1_29 Vdout1_29ck157 = 0 time = 1580
.meas tran vdout1_29ck157 FIND v(dout1_29) AT=1580.05n

* CHECK dout1_30 Vdout1_30ck157 = 1.8 time = 1580
.meas tran vdout1_30ck157 FIND v(dout1_30) AT=1580.05n

* CHECK dout1_31 Vdout1_31ck157 = 0 time = 1580
.meas tran vdout1_31ck157 FIND v(dout1_31) AT=1580.05n

* CHECK dout1_0 Vdout1_0ck158 = 1.8 time = 1590
.meas tran vdout1_0ck158 FIND v(dout1_0) AT=1590.05n

* CHECK dout1_1 Vdout1_1ck158 = 0 time = 1590
.meas tran vdout1_1ck158 FIND v(dout1_1) AT=1590.05n

* CHECK dout1_2 Vdout1_2ck158 = 0 time = 1590
.meas tran vdout1_2ck158 FIND v(dout1_2) AT=1590.05n

* CHECK dout1_3 Vdout1_3ck158 = 0 time = 1590
.meas tran vdout1_3ck158 FIND v(dout1_3) AT=1590.05n

* CHECK dout1_4 Vdout1_4ck158 = 1.8 time = 1590
.meas tran vdout1_4ck158 FIND v(dout1_4) AT=1590.05n

* CHECK dout1_5 Vdout1_5ck158 = 0 time = 1590
.meas tran vdout1_5ck158 FIND v(dout1_5) AT=1590.05n

* CHECK dout1_6 Vdout1_6ck158 = 0 time = 1590
.meas tran vdout1_6ck158 FIND v(dout1_6) AT=1590.05n

* CHECK dout1_7 Vdout1_7ck158 = 0 time = 1590
.meas tran vdout1_7ck158 FIND v(dout1_7) AT=1590.05n

* CHECK dout1_8 Vdout1_8ck158 = 1.8 time = 1590
.meas tran vdout1_8ck158 FIND v(dout1_8) AT=1590.05n

* CHECK dout1_9 Vdout1_9ck158 = 1.8 time = 1590
.meas tran vdout1_9ck158 FIND v(dout1_9) AT=1590.05n

* CHECK dout1_10 Vdout1_10ck158 = 1.8 time = 1590
.meas tran vdout1_10ck158 FIND v(dout1_10) AT=1590.05n

* CHECK dout1_11 Vdout1_11ck158 = 0 time = 1590
.meas tran vdout1_11ck158 FIND v(dout1_11) AT=1590.05n

* CHECK dout1_12 Vdout1_12ck158 = 0 time = 1590
.meas tran vdout1_12ck158 FIND v(dout1_12) AT=1590.05n

* CHECK dout1_13 Vdout1_13ck158 = 0 time = 1590
.meas tran vdout1_13ck158 FIND v(dout1_13) AT=1590.05n

* CHECK dout1_14 Vdout1_14ck158 = 1.8 time = 1590
.meas tran vdout1_14ck158 FIND v(dout1_14) AT=1590.05n

* CHECK dout1_15 Vdout1_15ck158 = 1.8 time = 1590
.meas tran vdout1_15ck158 FIND v(dout1_15) AT=1590.05n

* CHECK dout1_16 Vdout1_16ck158 = 1.8 time = 1590
.meas tran vdout1_16ck158 FIND v(dout1_16) AT=1590.05n

* CHECK dout1_17 Vdout1_17ck158 = 1.8 time = 1590
.meas tran vdout1_17ck158 FIND v(dout1_17) AT=1590.05n

* CHECK dout1_18 Vdout1_18ck158 = 1.8 time = 1590
.meas tran vdout1_18ck158 FIND v(dout1_18) AT=1590.05n

* CHECK dout1_19 Vdout1_19ck158 = 0 time = 1590
.meas tran vdout1_19ck158 FIND v(dout1_19) AT=1590.05n

* CHECK dout1_20 Vdout1_20ck158 = 0 time = 1590
.meas tran vdout1_20ck158 FIND v(dout1_20) AT=1590.05n

* CHECK dout1_21 Vdout1_21ck158 = 0 time = 1590
.meas tran vdout1_21ck158 FIND v(dout1_21) AT=1590.05n

* CHECK dout1_22 Vdout1_22ck158 = 1.8 time = 1590
.meas tran vdout1_22ck158 FIND v(dout1_22) AT=1590.05n

* CHECK dout1_23 Vdout1_23ck158 = 0 time = 1590
.meas tran vdout1_23ck158 FIND v(dout1_23) AT=1590.05n

* CHECK dout1_24 Vdout1_24ck158 = 1.8 time = 1590
.meas tran vdout1_24ck158 FIND v(dout1_24) AT=1590.05n

* CHECK dout1_25 Vdout1_25ck158 = 1.8 time = 1590
.meas tran vdout1_25ck158 FIND v(dout1_25) AT=1590.05n

* CHECK dout1_26 Vdout1_26ck158 = 1.8 time = 1590
.meas tran vdout1_26ck158 FIND v(dout1_26) AT=1590.05n

* CHECK dout1_27 Vdout1_27ck158 = 0 time = 1590
.meas tran vdout1_27ck158 FIND v(dout1_27) AT=1590.05n

* CHECK dout1_28 Vdout1_28ck158 = 0 time = 1590
.meas tran vdout1_28ck158 FIND v(dout1_28) AT=1590.05n

* CHECK dout1_29 Vdout1_29ck158 = 1.8 time = 1590
.meas tran vdout1_29ck158 FIND v(dout1_29) AT=1590.05n

* CHECK dout1_30 Vdout1_30ck158 = 1.8 time = 1590
.meas tran vdout1_30ck158 FIND v(dout1_30) AT=1590.05n

* CHECK dout1_31 Vdout1_31ck158 = 1.8 time = 1590
.meas tran vdout1_31ck158 FIND v(dout1_31) AT=1590.05n

* CHECK dout1_0 Vdout1_0ck159 = 0 time = 1600
.meas tran vdout1_0ck159 FIND v(dout1_0) AT=1600.05n

* CHECK dout1_1 Vdout1_1ck159 = 1.8 time = 1600
.meas tran vdout1_1ck159 FIND v(dout1_1) AT=1600.05n

* CHECK dout1_2 Vdout1_2ck159 = 0 time = 1600
.meas tran vdout1_2ck159 FIND v(dout1_2) AT=1600.05n

* CHECK dout1_3 Vdout1_3ck159 = 0 time = 1600
.meas tran vdout1_3ck159 FIND v(dout1_3) AT=1600.05n

* CHECK dout1_4 Vdout1_4ck159 = 0 time = 1600
.meas tran vdout1_4ck159 FIND v(dout1_4) AT=1600.05n

* CHECK dout1_5 Vdout1_5ck159 = 1.8 time = 1600
.meas tran vdout1_5ck159 FIND v(dout1_5) AT=1600.05n

* CHECK dout1_6 Vdout1_6ck159 = 0 time = 1600
.meas tran vdout1_6ck159 FIND v(dout1_6) AT=1600.05n

* CHECK dout1_7 Vdout1_7ck159 = 0 time = 1600
.meas tran vdout1_7ck159 FIND v(dout1_7) AT=1600.05n

* CHECK dout1_8 Vdout1_8ck159 = 1.8 time = 1600
.meas tran vdout1_8ck159 FIND v(dout1_8) AT=1600.05n

* CHECK dout1_9 Vdout1_9ck159 = 1.8 time = 1600
.meas tran vdout1_9ck159 FIND v(dout1_9) AT=1600.05n

* CHECK dout1_10 Vdout1_10ck159 = 0 time = 1600
.meas tran vdout1_10ck159 FIND v(dout1_10) AT=1600.05n

* CHECK dout1_11 Vdout1_11ck159 = 0 time = 1600
.meas tran vdout1_11ck159 FIND v(dout1_11) AT=1600.05n

* CHECK dout1_12 Vdout1_12ck159 = 1.8 time = 1600
.meas tran vdout1_12ck159 FIND v(dout1_12) AT=1600.05n

* CHECK dout1_13 Vdout1_13ck159 = 1.8 time = 1600
.meas tran vdout1_13ck159 FIND v(dout1_13) AT=1600.05n

* CHECK dout1_14 Vdout1_14ck159 = 1.8 time = 1600
.meas tran vdout1_14ck159 FIND v(dout1_14) AT=1600.05n

* CHECK dout1_15 Vdout1_15ck159 = 0 time = 1600
.meas tran vdout1_15ck159 FIND v(dout1_15) AT=1600.05n

* CHECK dout1_16 Vdout1_16ck159 = 1.8 time = 1600
.meas tran vdout1_16ck159 FIND v(dout1_16) AT=1600.05n

* CHECK dout1_17 Vdout1_17ck159 = 0 time = 1600
.meas tran vdout1_17ck159 FIND v(dout1_17) AT=1600.05n

* CHECK dout1_18 Vdout1_18ck159 = 0 time = 1600
.meas tran vdout1_18ck159 FIND v(dout1_18) AT=1600.05n

* CHECK dout1_19 Vdout1_19ck159 = 1.8 time = 1600
.meas tran vdout1_19ck159 FIND v(dout1_19) AT=1600.05n

* CHECK dout1_20 Vdout1_20ck159 = 1.8 time = 1600
.meas tran vdout1_20ck159 FIND v(dout1_20) AT=1600.05n

* CHECK dout1_21 Vdout1_21ck159 = 0 time = 1600
.meas tran vdout1_21ck159 FIND v(dout1_21) AT=1600.05n

* CHECK dout1_22 Vdout1_22ck159 = 0 time = 1600
.meas tran vdout1_22ck159 FIND v(dout1_22) AT=1600.05n

* CHECK dout1_23 Vdout1_23ck159 = 1.8 time = 1600
.meas tran vdout1_23ck159 FIND v(dout1_23) AT=1600.05n

* CHECK dout1_24 Vdout1_24ck159 = 1.8 time = 1600
.meas tran vdout1_24ck159 FIND v(dout1_24) AT=1600.05n

* CHECK dout1_25 Vdout1_25ck159 = 1.8 time = 1600
.meas tran vdout1_25ck159 FIND v(dout1_25) AT=1600.05n

* CHECK dout1_26 Vdout1_26ck159 = 0 time = 1600
.meas tran vdout1_26ck159 FIND v(dout1_26) AT=1600.05n

* CHECK dout1_27 Vdout1_27ck159 = 0 time = 1600
.meas tran vdout1_27ck159 FIND v(dout1_27) AT=1600.05n

* CHECK dout1_28 Vdout1_28ck159 = 0 time = 1600
.meas tran vdout1_28ck159 FIND v(dout1_28) AT=1600.05n

* CHECK dout1_29 Vdout1_29ck159 = 0 time = 1600
.meas tran vdout1_29ck159 FIND v(dout1_29) AT=1600.05n

* CHECK dout1_30 Vdout1_30ck159 = 1.8 time = 1600
.meas tran vdout1_30ck159 FIND v(dout1_30) AT=1600.05n

* CHECK dout1_31 Vdout1_31ck159 = 1.8 time = 1600
.meas tran vdout1_31ck159 FIND v(dout1_31) AT=1600.05n

* CHECK dout1_0 Vdout1_0ck160 = 0 time = 1610
.meas tran vdout1_0ck160 FIND v(dout1_0) AT=1610.05n

* CHECK dout1_1 Vdout1_1ck160 = 0 time = 1610
.meas tran vdout1_1ck160 FIND v(dout1_1) AT=1610.05n

* CHECK dout1_2 Vdout1_2ck160 = 1.8 time = 1610
.meas tran vdout1_2ck160 FIND v(dout1_2) AT=1610.05n

* CHECK dout1_3 Vdout1_3ck160 = 0 time = 1610
.meas tran vdout1_3ck160 FIND v(dout1_3) AT=1610.05n

* CHECK dout1_4 Vdout1_4ck160 = 1.8 time = 1610
.meas tran vdout1_4ck160 FIND v(dout1_4) AT=1610.05n

* CHECK dout1_5 Vdout1_5ck160 = 0 time = 1610
.meas tran vdout1_5ck160 FIND v(dout1_5) AT=1610.05n

* CHECK dout1_6 Vdout1_6ck160 = 0 time = 1610
.meas tran vdout1_6ck160 FIND v(dout1_6) AT=1610.05n

* CHECK dout1_7 Vdout1_7ck160 = 0 time = 1610
.meas tran vdout1_7ck160 FIND v(dout1_7) AT=1610.05n

* CHECK dout1_8 Vdout1_8ck160 = 1.8 time = 1610
.meas tran vdout1_8ck160 FIND v(dout1_8) AT=1610.05n

* CHECK dout1_9 Vdout1_9ck160 = 0 time = 1610
.meas tran vdout1_9ck160 FIND v(dout1_9) AT=1610.05n

* CHECK dout1_10 Vdout1_10ck160 = 0 time = 1610
.meas tran vdout1_10ck160 FIND v(dout1_10) AT=1610.05n

* CHECK dout1_11 Vdout1_11ck160 = 0 time = 1610
.meas tran vdout1_11ck160 FIND v(dout1_11) AT=1610.05n

* CHECK dout1_12 Vdout1_12ck160 = 1.8 time = 1610
.meas tran vdout1_12ck160 FIND v(dout1_12) AT=1610.05n

* CHECK dout1_13 Vdout1_13ck160 = 1.8 time = 1610
.meas tran vdout1_13ck160 FIND v(dout1_13) AT=1610.05n

* CHECK dout1_14 Vdout1_14ck160 = 1.8 time = 1610
.meas tran vdout1_14ck160 FIND v(dout1_14) AT=1610.05n

* CHECK dout1_15 Vdout1_15ck160 = 0 time = 1610
.meas tran vdout1_15ck160 FIND v(dout1_15) AT=1610.05n

* CHECK dout1_16 Vdout1_16ck160 = 1.8 time = 1610
.meas tran vdout1_16ck160 FIND v(dout1_16) AT=1610.05n

* CHECK dout1_17 Vdout1_17ck160 = 1.8 time = 1610
.meas tran vdout1_17ck160 FIND v(dout1_17) AT=1610.05n

* CHECK dout1_18 Vdout1_18ck160 = 1.8 time = 1610
.meas tran vdout1_18ck160 FIND v(dout1_18) AT=1610.05n

* CHECK dout1_19 Vdout1_19ck160 = 0 time = 1610
.meas tran vdout1_19ck160 FIND v(dout1_19) AT=1610.05n

* CHECK dout1_20 Vdout1_20ck160 = 0 time = 1610
.meas tran vdout1_20ck160 FIND v(dout1_20) AT=1610.05n

* CHECK dout1_21 Vdout1_21ck160 = 0 time = 1610
.meas tran vdout1_21ck160 FIND v(dout1_21) AT=1610.05n

* CHECK dout1_22 Vdout1_22ck160 = 1.8 time = 1610
.meas tran vdout1_22ck160 FIND v(dout1_22) AT=1610.05n

* CHECK dout1_23 Vdout1_23ck160 = 0 time = 1610
.meas tran vdout1_23ck160 FIND v(dout1_23) AT=1610.05n

* CHECK dout1_24 Vdout1_24ck160 = 1.8 time = 1610
.meas tran vdout1_24ck160 FIND v(dout1_24) AT=1610.05n

* CHECK dout1_25 Vdout1_25ck160 = 0 time = 1610
.meas tran vdout1_25ck160 FIND v(dout1_25) AT=1610.05n

* CHECK dout1_26 Vdout1_26ck160 = 1.8 time = 1610
.meas tran vdout1_26ck160 FIND v(dout1_26) AT=1610.05n

* CHECK dout1_27 Vdout1_27ck160 = 0 time = 1610
.meas tran vdout1_27ck160 FIND v(dout1_27) AT=1610.05n

* CHECK dout1_28 Vdout1_28ck160 = 0 time = 1610
.meas tran vdout1_28ck160 FIND v(dout1_28) AT=1610.05n

* CHECK dout1_29 Vdout1_29ck160 = 1.8 time = 1610
.meas tran vdout1_29ck160 FIND v(dout1_29) AT=1610.05n

* CHECK dout1_30 Vdout1_30ck160 = 0 time = 1610
.meas tran vdout1_30ck160 FIND v(dout1_30) AT=1610.05n

* CHECK dout1_31 Vdout1_31ck160 = 1.8 time = 1610
.meas tran vdout1_31ck160 FIND v(dout1_31) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck161 = 0 time = 1620
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=1620.05n

* CHECK dout0_1 Vdout0_1ck161 = 1.8 time = 1620
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=1620.05n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 1620
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=1620.05n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 1620
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=1620.05n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 1620
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=1620.05n

* CHECK dout0_5 Vdout0_5ck161 = 1.8 time = 1620
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=1620.05n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 1620
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=1620.05n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 1620
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=1620.05n

* CHECK dout0_8 Vdout0_8ck161 = 1.8 time = 1620
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=1620.05n

* CHECK dout0_9 Vdout0_9ck161 = 1.8 time = 1620
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=1620.05n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 1620
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=1620.05n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 1620
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=1620.05n

* CHECK dout0_12 Vdout0_12ck161 = 1.8 time = 1620
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=1620.05n

* CHECK dout0_13 Vdout0_13ck161 = 1.8 time = 1620
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=1620.05n

* CHECK dout0_14 Vdout0_14ck161 = 1.8 time = 1620
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=1620.05n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 1620
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=1620.05n

* CHECK dout0_16 Vdout0_16ck161 = 1.8 time = 1620
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=1620.05n

* CHECK dout0_17 Vdout0_17ck161 = 0 time = 1620
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=1620.05n

* CHECK dout0_18 Vdout0_18ck161 = 0 time = 1620
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=1620.05n

* CHECK dout0_19 Vdout0_19ck161 = 1.8 time = 1620
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=1620.05n

* CHECK dout0_20 Vdout0_20ck161 = 1.8 time = 1620
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=1620.05n

* CHECK dout0_21 Vdout0_21ck161 = 0 time = 1620
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=1620.05n

* CHECK dout0_22 Vdout0_22ck161 = 0 time = 1620
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=1620.05n

* CHECK dout0_23 Vdout0_23ck161 = 1.8 time = 1620
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=1620.05n

* CHECK dout0_24 Vdout0_24ck161 = 1.8 time = 1620
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=1620.05n

* CHECK dout0_25 Vdout0_25ck161 = 1.8 time = 1620
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=1620.05n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 1620
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=1620.05n

* CHECK dout0_27 Vdout0_27ck161 = 0 time = 1620
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=1620.05n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 1620
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=1620.05n

* CHECK dout0_29 Vdout0_29ck161 = 0 time = 1620
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=1620.05n

* CHECK dout0_30 Vdout0_30ck161 = 1.8 time = 1620
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=1620.05n

* CHECK dout0_31 Vdout0_31ck161 = 1.8 time = 1620
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=1620.05n

* CHECK dout1_0 Vdout1_0ck161 = 1.8 time = 1620
.meas tran vdout1_0ck161 FIND v(dout1_0) AT=1620.05n

* CHECK dout1_1 Vdout1_1ck161 = 0 time = 1620
.meas tran vdout1_1ck161 FIND v(dout1_1) AT=1620.05n

* CHECK dout1_2 Vdout1_2ck161 = 0 time = 1620
.meas tran vdout1_2ck161 FIND v(dout1_2) AT=1620.05n

* CHECK dout1_3 Vdout1_3ck161 = 0 time = 1620
.meas tran vdout1_3ck161 FIND v(dout1_3) AT=1620.05n

* CHECK dout1_4 Vdout1_4ck161 = 1.8 time = 1620
.meas tran vdout1_4ck161 FIND v(dout1_4) AT=1620.05n

* CHECK dout1_5 Vdout1_5ck161 = 0 time = 1620
.meas tran vdout1_5ck161 FIND v(dout1_5) AT=1620.05n

* CHECK dout1_6 Vdout1_6ck161 = 0 time = 1620
.meas tran vdout1_6ck161 FIND v(dout1_6) AT=1620.05n

* CHECK dout1_7 Vdout1_7ck161 = 0 time = 1620
.meas tran vdout1_7ck161 FIND v(dout1_7) AT=1620.05n

* CHECK dout1_8 Vdout1_8ck161 = 1.8 time = 1620
.meas tran vdout1_8ck161 FIND v(dout1_8) AT=1620.05n

* CHECK dout1_9 Vdout1_9ck161 = 1.8 time = 1620
.meas tran vdout1_9ck161 FIND v(dout1_9) AT=1620.05n

* CHECK dout1_10 Vdout1_10ck161 = 1.8 time = 1620
.meas tran vdout1_10ck161 FIND v(dout1_10) AT=1620.05n

* CHECK dout1_11 Vdout1_11ck161 = 0 time = 1620
.meas tran vdout1_11ck161 FIND v(dout1_11) AT=1620.05n

* CHECK dout1_12 Vdout1_12ck161 = 0 time = 1620
.meas tran vdout1_12ck161 FIND v(dout1_12) AT=1620.05n

* CHECK dout1_13 Vdout1_13ck161 = 0 time = 1620
.meas tran vdout1_13ck161 FIND v(dout1_13) AT=1620.05n

* CHECK dout1_14 Vdout1_14ck161 = 1.8 time = 1620
.meas tran vdout1_14ck161 FIND v(dout1_14) AT=1620.05n

* CHECK dout1_15 Vdout1_15ck161 = 1.8 time = 1620
.meas tran vdout1_15ck161 FIND v(dout1_15) AT=1620.05n

* CHECK dout1_16 Vdout1_16ck161 = 1.8 time = 1620
.meas tran vdout1_16ck161 FIND v(dout1_16) AT=1620.05n

* CHECK dout1_17 Vdout1_17ck161 = 0 time = 1620
.meas tran vdout1_17ck161 FIND v(dout1_17) AT=1620.05n

* CHECK dout1_18 Vdout1_18ck161 = 0 time = 1620
.meas tran vdout1_18ck161 FIND v(dout1_18) AT=1620.05n

* CHECK dout1_19 Vdout1_19ck161 = 0 time = 1620
.meas tran vdout1_19ck161 FIND v(dout1_19) AT=1620.05n

* CHECK dout1_20 Vdout1_20ck161 = 0 time = 1620
.meas tran vdout1_20ck161 FIND v(dout1_20) AT=1620.05n

* CHECK dout1_21 Vdout1_21ck161 = 1.8 time = 1620
.meas tran vdout1_21ck161 FIND v(dout1_21) AT=1620.05n

* CHECK dout1_22 Vdout1_22ck161 = 1.8 time = 1620
.meas tran vdout1_22ck161 FIND v(dout1_22) AT=1620.05n

* CHECK dout1_23 Vdout1_23ck161 = 0 time = 1620
.meas tran vdout1_23ck161 FIND v(dout1_23) AT=1620.05n

* CHECK dout1_24 Vdout1_24ck161 = 1.8 time = 1620
.meas tran vdout1_24ck161 FIND v(dout1_24) AT=1620.05n

* CHECK dout1_25 Vdout1_25ck161 = 1.8 time = 1620
.meas tran vdout1_25ck161 FIND v(dout1_25) AT=1620.05n

* CHECK dout1_26 Vdout1_26ck161 = 1.8 time = 1620
.meas tran vdout1_26ck161 FIND v(dout1_26) AT=1620.05n

* CHECK dout1_27 Vdout1_27ck161 = 0 time = 1620
.meas tran vdout1_27ck161 FIND v(dout1_27) AT=1620.05n

* CHECK dout1_28 Vdout1_28ck161 = 0 time = 1620
.meas tran vdout1_28ck161 FIND v(dout1_28) AT=1620.05n

* CHECK dout1_29 Vdout1_29ck161 = 1.8 time = 1620
.meas tran vdout1_29ck161 FIND v(dout1_29) AT=1620.05n

* CHECK dout1_30 Vdout1_30ck161 = 1.8 time = 1620
.meas tran vdout1_30ck161 FIND v(dout1_30) AT=1620.05n

* CHECK dout1_31 Vdout1_31ck161 = 1.8 time = 1620
.meas tran vdout1_31ck161 FIND v(dout1_31) AT=1620.05n

* CHECK dout0_0 Vdout0_0ck164 = 0 time = 1650
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=1650.05n

* CHECK dout0_1 Vdout0_1ck164 = 1.8 time = 1650
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=1650.05n

* CHECK dout0_2 Vdout0_2ck164 = 0 time = 1650
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=1650.05n

* CHECK dout0_3 Vdout0_3ck164 = 0 time = 1650
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=1650.05n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 1650
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=1650.05n

* CHECK dout0_5 Vdout0_5ck164 = 1.8 time = 1650
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=1650.05n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 1650
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=1650.05n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 1650
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=1650.05n

* CHECK dout0_8 Vdout0_8ck164 = 1.8 time = 1650
.meas tran vdout0_8ck164 FIND v(dout0_8) AT=1650.05n

* CHECK dout0_9 Vdout0_9ck164 = 1.8 time = 1650
.meas tran vdout0_9ck164 FIND v(dout0_9) AT=1650.05n

* CHECK dout0_10 Vdout0_10ck164 = 0 time = 1650
.meas tran vdout0_10ck164 FIND v(dout0_10) AT=1650.05n

* CHECK dout0_11 Vdout0_11ck164 = 0 time = 1650
.meas tran vdout0_11ck164 FIND v(dout0_11) AT=1650.05n

* CHECK dout0_12 Vdout0_12ck164 = 1.8 time = 1650
.meas tran vdout0_12ck164 FIND v(dout0_12) AT=1650.05n

* CHECK dout0_13 Vdout0_13ck164 = 1.8 time = 1650
.meas tran vdout0_13ck164 FIND v(dout0_13) AT=1650.05n

* CHECK dout0_14 Vdout0_14ck164 = 1.8 time = 1650
.meas tran vdout0_14ck164 FIND v(dout0_14) AT=1650.05n

* CHECK dout0_15 Vdout0_15ck164 = 0 time = 1650
.meas tran vdout0_15ck164 FIND v(dout0_15) AT=1650.05n

* CHECK dout0_16 Vdout0_16ck164 = 1.8 time = 1650
.meas tran vdout0_16ck164 FIND v(dout0_16) AT=1650.05n

* CHECK dout0_17 Vdout0_17ck164 = 0 time = 1650
.meas tran vdout0_17ck164 FIND v(dout0_17) AT=1650.05n

* CHECK dout0_18 Vdout0_18ck164 = 0 time = 1650
.meas tran vdout0_18ck164 FIND v(dout0_18) AT=1650.05n

* CHECK dout0_19 Vdout0_19ck164 = 1.8 time = 1650
.meas tran vdout0_19ck164 FIND v(dout0_19) AT=1650.05n

* CHECK dout0_20 Vdout0_20ck164 = 1.8 time = 1650
.meas tran vdout0_20ck164 FIND v(dout0_20) AT=1650.05n

* CHECK dout0_21 Vdout0_21ck164 = 0 time = 1650
.meas tran vdout0_21ck164 FIND v(dout0_21) AT=1650.05n

* CHECK dout0_22 Vdout0_22ck164 = 0 time = 1650
.meas tran vdout0_22ck164 FIND v(dout0_22) AT=1650.05n

* CHECK dout0_23 Vdout0_23ck164 = 1.8 time = 1650
.meas tran vdout0_23ck164 FIND v(dout0_23) AT=1650.05n

* CHECK dout0_24 Vdout0_24ck164 = 1.8 time = 1650
.meas tran vdout0_24ck164 FIND v(dout0_24) AT=1650.05n

* CHECK dout0_25 Vdout0_25ck164 = 1.8 time = 1650
.meas tran vdout0_25ck164 FIND v(dout0_25) AT=1650.05n

* CHECK dout0_26 Vdout0_26ck164 = 0 time = 1650
.meas tran vdout0_26ck164 FIND v(dout0_26) AT=1650.05n

* CHECK dout0_27 Vdout0_27ck164 = 0 time = 1650
.meas tran vdout0_27ck164 FIND v(dout0_27) AT=1650.05n

* CHECK dout0_28 Vdout0_28ck164 = 0 time = 1650
.meas tran vdout0_28ck164 FIND v(dout0_28) AT=1650.05n

* CHECK dout0_29 Vdout0_29ck164 = 0 time = 1650
.meas tran vdout0_29ck164 FIND v(dout0_29) AT=1650.05n

* CHECK dout0_30 Vdout0_30ck164 = 1.8 time = 1650
.meas tran vdout0_30ck164 FIND v(dout0_30) AT=1650.05n

* CHECK dout0_31 Vdout0_31ck164 = 1.8 time = 1650
.meas tran vdout0_31ck164 FIND v(dout0_31) AT=1650.05n

* CHECK dout0_0 Vdout0_0ck166 = 1.8 time = 1670
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=1670.05n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 1670
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=1670.05n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 1670
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=1670.05n

* CHECK dout0_3 Vdout0_3ck166 = 1.8 time = 1670
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=1670.05n

* CHECK dout0_4 Vdout0_4ck166 = 1.8 time = 1670
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=1670.05n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 1670
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=1670.05n

* CHECK dout0_6 Vdout0_6ck166 = 1.8 time = 1670
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=1670.05n

* CHECK dout0_7 Vdout0_7ck166 = 1.8 time = 1670
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=1670.05n

* CHECK dout0_8 Vdout0_8ck166 = 0 time = 1670
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=1670.05n

* CHECK dout0_9 Vdout0_9ck166 = 1.8 time = 1670
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=1670.05n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 1670
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=1670.05n

* CHECK dout0_11 Vdout0_11ck166 = 0 time = 1670
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=1670.05n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 1670
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=1670.05n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 1670
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=1670.05n

* CHECK dout0_14 Vdout0_14ck166 = 1.8 time = 1670
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=1670.05n

* CHECK dout0_15 Vdout0_15ck166 = 0 time = 1670
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=1670.05n

* CHECK dout0_16 Vdout0_16ck166 = 1.8 time = 1670
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=1670.05n

* CHECK dout0_17 Vdout0_17ck166 = 1.8 time = 1670
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=1670.05n

* CHECK dout0_18 Vdout0_18ck166 = 1.8 time = 1670
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=1670.05n

* CHECK dout0_19 Vdout0_19ck166 = 0 time = 1670
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=1670.05n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 1670
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=1670.05n

* CHECK dout0_21 Vdout0_21ck166 = 0 time = 1670
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=1670.05n

* CHECK dout0_22 Vdout0_22ck166 = 0 time = 1670
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=1670.05n

* CHECK dout0_23 Vdout0_23ck166 = 1.8 time = 1670
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=1670.05n

* CHECK dout0_24 Vdout0_24ck166 = 0 time = 1670
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=1670.05n

* CHECK dout0_25 Vdout0_25ck166 = 1.8 time = 1670
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=1670.05n

* CHECK dout0_26 Vdout0_26ck166 = 1.8 time = 1670
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=1670.05n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 1670
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=1670.05n

* CHECK dout0_28 Vdout0_28ck166 = 1.8 time = 1670
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=1670.05n

* CHECK dout0_29 Vdout0_29ck166 = 0 time = 1670
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=1670.05n

* CHECK dout0_30 Vdout0_30ck166 = 1.8 time = 1670
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=1670.05n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 1670
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=1670.05n

* CHECK dout1_0 Vdout1_0ck168 = 1.8 time = 1690
.meas tran vdout1_0ck168 FIND v(dout1_0) AT=1690.05n

* CHECK dout1_1 Vdout1_1ck168 = 0 time = 1690
.meas tran vdout1_1ck168 FIND v(dout1_1) AT=1690.05n

* CHECK dout1_2 Vdout1_2ck168 = 0 time = 1690
.meas tran vdout1_2ck168 FIND v(dout1_2) AT=1690.05n

* CHECK dout1_3 Vdout1_3ck168 = 0 time = 1690
.meas tran vdout1_3ck168 FIND v(dout1_3) AT=1690.05n

* CHECK dout1_4 Vdout1_4ck168 = 1.8 time = 1690
.meas tran vdout1_4ck168 FIND v(dout1_4) AT=1690.05n

* CHECK dout1_5 Vdout1_5ck168 = 0 time = 1690
.meas tran vdout1_5ck168 FIND v(dout1_5) AT=1690.05n

* CHECK dout1_6 Vdout1_6ck168 = 0 time = 1690
.meas tran vdout1_6ck168 FIND v(dout1_6) AT=1690.05n

* CHECK dout1_7 Vdout1_7ck168 = 0 time = 1690
.meas tran vdout1_7ck168 FIND v(dout1_7) AT=1690.05n

* CHECK dout1_8 Vdout1_8ck168 = 1.8 time = 1690
.meas tran vdout1_8ck168 FIND v(dout1_8) AT=1690.05n

* CHECK dout1_9 Vdout1_9ck168 = 1.8 time = 1690
.meas tran vdout1_9ck168 FIND v(dout1_9) AT=1690.05n

* CHECK dout1_10 Vdout1_10ck168 = 1.8 time = 1690
.meas tran vdout1_10ck168 FIND v(dout1_10) AT=1690.05n

* CHECK dout1_11 Vdout1_11ck168 = 0 time = 1690
.meas tran vdout1_11ck168 FIND v(dout1_11) AT=1690.05n

* CHECK dout1_12 Vdout1_12ck168 = 0 time = 1690
.meas tran vdout1_12ck168 FIND v(dout1_12) AT=1690.05n

* CHECK dout1_13 Vdout1_13ck168 = 0 time = 1690
.meas tran vdout1_13ck168 FIND v(dout1_13) AT=1690.05n

* CHECK dout1_14 Vdout1_14ck168 = 1.8 time = 1690
.meas tran vdout1_14ck168 FIND v(dout1_14) AT=1690.05n

* CHECK dout1_15 Vdout1_15ck168 = 1.8 time = 1690
.meas tran vdout1_15ck168 FIND v(dout1_15) AT=1690.05n

* CHECK dout1_16 Vdout1_16ck168 = 1.8 time = 1690
.meas tran vdout1_16ck168 FIND v(dout1_16) AT=1690.05n

* CHECK dout1_17 Vdout1_17ck168 = 0 time = 1690
.meas tran vdout1_17ck168 FIND v(dout1_17) AT=1690.05n

* CHECK dout1_18 Vdout1_18ck168 = 0 time = 1690
.meas tran vdout1_18ck168 FIND v(dout1_18) AT=1690.05n

* CHECK dout1_19 Vdout1_19ck168 = 0 time = 1690
.meas tran vdout1_19ck168 FIND v(dout1_19) AT=1690.05n

* CHECK dout1_20 Vdout1_20ck168 = 0 time = 1690
.meas tran vdout1_20ck168 FIND v(dout1_20) AT=1690.05n

* CHECK dout1_21 Vdout1_21ck168 = 1.8 time = 1690
.meas tran vdout1_21ck168 FIND v(dout1_21) AT=1690.05n

* CHECK dout1_22 Vdout1_22ck168 = 1.8 time = 1690
.meas tran vdout1_22ck168 FIND v(dout1_22) AT=1690.05n

* CHECK dout1_23 Vdout1_23ck168 = 0 time = 1690
.meas tran vdout1_23ck168 FIND v(dout1_23) AT=1690.05n

* CHECK dout1_24 Vdout1_24ck168 = 1.8 time = 1690
.meas tran vdout1_24ck168 FIND v(dout1_24) AT=1690.05n

* CHECK dout1_25 Vdout1_25ck168 = 1.8 time = 1690
.meas tran vdout1_25ck168 FIND v(dout1_25) AT=1690.05n

* CHECK dout1_26 Vdout1_26ck168 = 1.8 time = 1690
.meas tran vdout1_26ck168 FIND v(dout1_26) AT=1690.05n

* CHECK dout1_27 Vdout1_27ck168 = 0 time = 1690
.meas tran vdout1_27ck168 FIND v(dout1_27) AT=1690.05n

* CHECK dout1_28 Vdout1_28ck168 = 0 time = 1690
.meas tran vdout1_28ck168 FIND v(dout1_28) AT=1690.05n

* CHECK dout1_29 Vdout1_29ck168 = 1.8 time = 1690
.meas tran vdout1_29ck168 FIND v(dout1_29) AT=1690.05n

* CHECK dout1_30 Vdout1_30ck168 = 1.8 time = 1690
.meas tran vdout1_30ck168 FIND v(dout1_30) AT=1690.05n

* CHECK dout1_31 Vdout1_31ck168 = 1.8 time = 1690
.meas tran vdout1_31ck168 FIND v(dout1_31) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck170 = 0 time = 1710
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=1710.05n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 1710
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=1710.05n

* CHECK dout0_2 Vdout0_2ck170 = 0 time = 1710
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=1710.05n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 1710
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=1710.05n

* CHECK dout0_4 Vdout0_4ck170 = 1.8 time = 1710
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=1710.05n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 1710
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=1710.05n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 1710
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=1710.05n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 1710
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=1710.05n

* CHECK dout0_8 Vdout0_8ck170 = 0 time = 1710
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=1710.05n

* CHECK dout0_9 Vdout0_9ck170 = 1.8 time = 1710
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=1710.05n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 1710
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=1710.05n

* CHECK dout0_11 Vdout0_11ck170 = 0 time = 1710
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=1710.05n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 1710
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=1710.05n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 1710
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=1710.05n

* CHECK dout0_14 Vdout0_14ck170 = 0 time = 1710
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=1710.05n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 1710
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=1710.05n

* CHECK dout0_16 Vdout0_16ck170 = 1.8 time = 1710
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=1710.05n

* CHECK dout0_17 Vdout0_17ck170 = 0 time = 1710
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=1710.05n

* CHECK dout0_18 Vdout0_18ck170 = 1.8 time = 1710
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=1710.05n

* CHECK dout0_19 Vdout0_19ck170 = 0 time = 1710
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=1710.05n

* CHECK dout0_20 Vdout0_20ck170 = 0 time = 1710
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=1710.05n

* CHECK dout0_21 Vdout0_21ck170 = 1.8 time = 1710
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=1710.05n

* CHECK dout0_22 Vdout0_22ck170 = 0 time = 1710
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=1710.05n

* CHECK dout0_23 Vdout0_23ck170 = 0 time = 1710
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=1710.05n

* CHECK dout0_24 Vdout0_24ck170 = 1.8 time = 1710
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=1710.05n

* CHECK dout0_25 Vdout0_25ck170 = 1.8 time = 1710
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=1710.05n

* CHECK dout0_26 Vdout0_26ck170 = 1.8 time = 1710
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=1710.05n

* CHECK dout0_27 Vdout0_27ck170 = 0 time = 1710
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=1710.05n

* CHECK dout0_28 Vdout0_28ck170 = 0 time = 1710
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=1710.05n

* CHECK dout0_29 Vdout0_29ck170 = 0 time = 1710
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=1710.05n

* CHECK dout0_30 Vdout0_30ck170 = 0 time = 1710
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=1710.05n

* CHECK dout0_31 Vdout0_31ck170 = 1.8 time = 1710
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=1710.05n

* CHECK dout1_0 Vdout1_0ck170 = 0 time = 1710
.meas tran vdout1_0ck170 FIND v(dout1_0) AT=1710.05n

* CHECK dout1_1 Vdout1_1ck170 = 0 time = 1710
.meas tran vdout1_1ck170 FIND v(dout1_1) AT=1710.05n

* CHECK dout1_2 Vdout1_2ck170 = 1.8 time = 1710
.meas tran vdout1_2ck170 FIND v(dout1_2) AT=1710.05n

* CHECK dout1_3 Vdout1_3ck170 = 0 time = 1710
.meas tran vdout1_3ck170 FIND v(dout1_3) AT=1710.05n

* CHECK dout1_4 Vdout1_4ck170 = 1.8 time = 1710
.meas tran vdout1_4ck170 FIND v(dout1_4) AT=1710.05n

* CHECK dout1_5 Vdout1_5ck170 = 0 time = 1710
.meas tran vdout1_5ck170 FIND v(dout1_5) AT=1710.05n

* CHECK dout1_6 Vdout1_6ck170 = 0 time = 1710
.meas tran vdout1_6ck170 FIND v(dout1_6) AT=1710.05n

* CHECK dout1_7 Vdout1_7ck170 = 0 time = 1710
.meas tran vdout1_7ck170 FIND v(dout1_7) AT=1710.05n

* CHECK dout1_8 Vdout1_8ck170 = 1.8 time = 1710
.meas tran vdout1_8ck170 FIND v(dout1_8) AT=1710.05n

* CHECK dout1_9 Vdout1_9ck170 = 0 time = 1710
.meas tran vdout1_9ck170 FIND v(dout1_9) AT=1710.05n

* CHECK dout1_10 Vdout1_10ck170 = 0 time = 1710
.meas tran vdout1_10ck170 FIND v(dout1_10) AT=1710.05n

* CHECK dout1_11 Vdout1_11ck170 = 0 time = 1710
.meas tran vdout1_11ck170 FIND v(dout1_11) AT=1710.05n

* CHECK dout1_12 Vdout1_12ck170 = 1.8 time = 1710
.meas tran vdout1_12ck170 FIND v(dout1_12) AT=1710.05n

* CHECK dout1_13 Vdout1_13ck170 = 1.8 time = 1710
.meas tran vdout1_13ck170 FIND v(dout1_13) AT=1710.05n

* CHECK dout1_14 Vdout1_14ck170 = 1.8 time = 1710
.meas tran vdout1_14ck170 FIND v(dout1_14) AT=1710.05n

* CHECK dout1_15 Vdout1_15ck170 = 0 time = 1710
.meas tran vdout1_15ck170 FIND v(dout1_15) AT=1710.05n

* CHECK dout1_16 Vdout1_16ck170 = 1.8 time = 1710
.meas tran vdout1_16ck170 FIND v(dout1_16) AT=1710.05n

* CHECK dout1_17 Vdout1_17ck170 = 1.8 time = 1710
.meas tran vdout1_17ck170 FIND v(dout1_17) AT=1710.05n

* CHECK dout1_18 Vdout1_18ck170 = 1.8 time = 1710
.meas tran vdout1_18ck170 FIND v(dout1_18) AT=1710.05n

* CHECK dout1_19 Vdout1_19ck170 = 0 time = 1710
.meas tran vdout1_19ck170 FIND v(dout1_19) AT=1710.05n

* CHECK dout1_20 Vdout1_20ck170 = 0 time = 1710
.meas tran vdout1_20ck170 FIND v(dout1_20) AT=1710.05n

* CHECK dout1_21 Vdout1_21ck170 = 0 time = 1710
.meas tran vdout1_21ck170 FIND v(dout1_21) AT=1710.05n

* CHECK dout1_22 Vdout1_22ck170 = 1.8 time = 1710
.meas tran vdout1_22ck170 FIND v(dout1_22) AT=1710.05n

* CHECK dout1_23 Vdout1_23ck170 = 0 time = 1710
.meas tran vdout1_23ck170 FIND v(dout1_23) AT=1710.05n

* CHECK dout1_24 Vdout1_24ck170 = 1.8 time = 1710
.meas tran vdout1_24ck170 FIND v(dout1_24) AT=1710.05n

* CHECK dout1_25 Vdout1_25ck170 = 0 time = 1710
.meas tran vdout1_25ck170 FIND v(dout1_25) AT=1710.05n

* CHECK dout1_26 Vdout1_26ck170 = 1.8 time = 1710
.meas tran vdout1_26ck170 FIND v(dout1_26) AT=1710.05n

* CHECK dout1_27 Vdout1_27ck170 = 0 time = 1710
.meas tran vdout1_27ck170 FIND v(dout1_27) AT=1710.05n

* CHECK dout1_28 Vdout1_28ck170 = 0 time = 1710
.meas tran vdout1_28ck170 FIND v(dout1_28) AT=1710.05n

* CHECK dout1_29 Vdout1_29ck170 = 1.8 time = 1710
.meas tran vdout1_29ck170 FIND v(dout1_29) AT=1710.05n

* CHECK dout1_30 Vdout1_30ck170 = 0 time = 1710
.meas tran vdout1_30ck170 FIND v(dout1_30) AT=1710.05n

* CHECK dout1_31 Vdout1_31ck170 = 1.8 time = 1710
.meas tran vdout1_31ck170 FIND v(dout1_31) AT=1710.05n

* CHECK dout1_0 Vdout1_0ck171 = 1.8 time = 1720
.meas tran vdout1_0ck171 FIND v(dout1_0) AT=1720.05n

* CHECK dout1_1 Vdout1_1ck171 = 0 time = 1720
.meas tran vdout1_1ck171 FIND v(dout1_1) AT=1720.05n

* CHECK dout1_2 Vdout1_2ck171 = 0 time = 1720
.meas tran vdout1_2ck171 FIND v(dout1_2) AT=1720.05n

* CHECK dout1_3 Vdout1_3ck171 = 0 time = 1720
.meas tran vdout1_3ck171 FIND v(dout1_3) AT=1720.05n

* CHECK dout1_4 Vdout1_4ck171 = 1.8 time = 1720
.meas tran vdout1_4ck171 FIND v(dout1_4) AT=1720.05n

* CHECK dout1_5 Vdout1_5ck171 = 0 time = 1720
.meas tran vdout1_5ck171 FIND v(dout1_5) AT=1720.05n

* CHECK dout1_6 Vdout1_6ck171 = 0 time = 1720
.meas tran vdout1_6ck171 FIND v(dout1_6) AT=1720.05n

* CHECK dout1_7 Vdout1_7ck171 = 0 time = 1720
.meas tran vdout1_7ck171 FIND v(dout1_7) AT=1720.05n

* CHECK dout1_8 Vdout1_8ck171 = 1.8 time = 1720
.meas tran vdout1_8ck171 FIND v(dout1_8) AT=1720.05n

* CHECK dout1_9 Vdout1_9ck171 = 1.8 time = 1720
.meas tran vdout1_9ck171 FIND v(dout1_9) AT=1720.05n

* CHECK dout1_10 Vdout1_10ck171 = 1.8 time = 1720
.meas tran vdout1_10ck171 FIND v(dout1_10) AT=1720.05n

* CHECK dout1_11 Vdout1_11ck171 = 0 time = 1720
.meas tran vdout1_11ck171 FIND v(dout1_11) AT=1720.05n

* CHECK dout1_12 Vdout1_12ck171 = 0 time = 1720
.meas tran vdout1_12ck171 FIND v(dout1_12) AT=1720.05n

* CHECK dout1_13 Vdout1_13ck171 = 0 time = 1720
.meas tran vdout1_13ck171 FIND v(dout1_13) AT=1720.05n

* CHECK dout1_14 Vdout1_14ck171 = 1.8 time = 1720
.meas tran vdout1_14ck171 FIND v(dout1_14) AT=1720.05n

* CHECK dout1_15 Vdout1_15ck171 = 1.8 time = 1720
.meas tran vdout1_15ck171 FIND v(dout1_15) AT=1720.05n

* CHECK dout1_16 Vdout1_16ck171 = 1.8 time = 1720
.meas tran vdout1_16ck171 FIND v(dout1_16) AT=1720.05n

* CHECK dout1_17 Vdout1_17ck171 = 0 time = 1720
.meas tran vdout1_17ck171 FIND v(dout1_17) AT=1720.05n

* CHECK dout1_18 Vdout1_18ck171 = 0 time = 1720
.meas tran vdout1_18ck171 FIND v(dout1_18) AT=1720.05n

* CHECK dout1_19 Vdout1_19ck171 = 0 time = 1720
.meas tran vdout1_19ck171 FIND v(dout1_19) AT=1720.05n

* CHECK dout1_20 Vdout1_20ck171 = 0 time = 1720
.meas tran vdout1_20ck171 FIND v(dout1_20) AT=1720.05n

* CHECK dout1_21 Vdout1_21ck171 = 1.8 time = 1720
.meas tran vdout1_21ck171 FIND v(dout1_21) AT=1720.05n

* CHECK dout1_22 Vdout1_22ck171 = 1.8 time = 1720
.meas tran vdout1_22ck171 FIND v(dout1_22) AT=1720.05n

* CHECK dout1_23 Vdout1_23ck171 = 0 time = 1720
.meas tran vdout1_23ck171 FIND v(dout1_23) AT=1720.05n

* CHECK dout1_24 Vdout1_24ck171 = 1.8 time = 1720
.meas tran vdout1_24ck171 FIND v(dout1_24) AT=1720.05n

* CHECK dout1_25 Vdout1_25ck171 = 1.8 time = 1720
.meas tran vdout1_25ck171 FIND v(dout1_25) AT=1720.05n

* CHECK dout1_26 Vdout1_26ck171 = 1.8 time = 1720
.meas tran vdout1_26ck171 FIND v(dout1_26) AT=1720.05n

* CHECK dout1_27 Vdout1_27ck171 = 0 time = 1720
.meas tran vdout1_27ck171 FIND v(dout1_27) AT=1720.05n

* CHECK dout1_28 Vdout1_28ck171 = 0 time = 1720
.meas tran vdout1_28ck171 FIND v(dout1_28) AT=1720.05n

* CHECK dout1_29 Vdout1_29ck171 = 1.8 time = 1720
.meas tran vdout1_29ck171 FIND v(dout1_29) AT=1720.05n

* CHECK dout1_30 Vdout1_30ck171 = 1.8 time = 1720
.meas tran vdout1_30ck171 FIND v(dout1_30) AT=1720.05n

* CHECK dout1_31 Vdout1_31ck171 = 1.8 time = 1720
.meas tran vdout1_31ck171 FIND v(dout1_31) AT=1720.05n

* CHECK dout0_0 Vdout0_0ck173 = 0 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 0 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 0 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 1.8 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 0 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_8 Vdout0_8ck173 = 0 time = 1740
.meas tran vdout0_8ck173 FIND v(dout0_8) AT=1740.05n

* CHECK dout0_9 Vdout0_9ck173 = 1.8 time = 1740
.meas tran vdout0_9ck173 FIND v(dout0_9) AT=1740.05n

* CHECK dout0_10 Vdout0_10ck173 = 1.8 time = 1740
.meas tran vdout0_10ck173 FIND v(dout0_10) AT=1740.05n

* CHECK dout0_11 Vdout0_11ck173 = 0 time = 1740
.meas tran vdout0_11ck173 FIND v(dout0_11) AT=1740.05n

* CHECK dout0_12 Vdout0_12ck173 = 0 time = 1740
.meas tran vdout0_12ck173 FIND v(dout0_12) AT=1740.05n

* CHECK dout0_13 Vdout0_13ck173 = 1.8 time = 1740
.meas tran vdout0_13ck173 FIND v(dout0_13) AT=1740.05n

* CHECK dout0_14 Vdout0_14ck173 = 0 time = 1740
.meas tran vdout0_14ck173 FIND v(dout0_14) AT=1740.05n

* CHECK dout0_15 Vdout0_15ck173 = 0 time = 1740
.meas tran vdout0_15ck173 FIND v(dout0_15) AT=1740.05n

* CHECK dout0_16 Vdout0_16ck173 = 1.8 time = 1740
.meas tran vdout0_16ck173 FIND v(dout0_16) AT=1740.05n

* CHECK dout0_17 Vdout0_17ck173 = 0 time = 1740
.meas tran vdout0_17ck173 FIND v(dout0_17) AT=1740.05n

* CHECK dout0_18 Vdout0_18ck173 = 1.8 time = 1740
.meas tran vdout0_18ck173 FIND v(dout0_18) AT=1740.05n

* CHECK dout0_19 Vdout0_19ck173 = 0 time = 1740
.meas tran vdout0_19ck173 FIND v(dout0_19) AT=1740.05n

* CHECK dout0_20 Vdout0_20ck173 = 0 time = 1740
.meas tran vdout0_20ck173 FIND v(dout0_20) AT=1740.05n

* CHECK dout0_21 Vdout0_21ck173 = 1.8 time = 1740
.meas tran vdout0_21ck173 FIND v(dout0_21) AT=1740.05n

* CHECK dout0_22 Vdout0_22ck173 = 0 time = 1740
.meas tran vdout0_22ck173 FIND v(dout0_22) AT=1740.05n

* CHECK dout0_23 Vdout0_23ck173 = 0 time = 1740
.meas tran vdout0_23ck173 FIND v(dout0_23) AT=1740.05n

* CHECK dout0_24 Vdout0_24ck173 = 1.8 time = 1740
.meas tran vdout0_24ck173 FIND v(dout0_24) AT=1740.05n

* CHECK dout0_25 Vdout0_25ck173 = 1.8 time = 1740
.meas tran vdout0_25ck173 FIND v(dout0_25) AT=1740.05n

* CHECK dout0_26 Vdout0_26ck173 = 1.8 time = 1740
.meas tran vdout0_26ck173 FIND v(dout0_26) AT=1740.05n

* CHECK dout0_27 Vdout0_27ck173 = 0 time = 1740
.meas tran vdout0_27ck173 FIND v(dout0_27) AT=1740.05n

* CHECK dout0_28 Vdout0_28ck173 = 0 time = 1740
.meas tran vdout0_28ck173 FIND v(dout0_28) AT=1740.05n

* CHECK dout0_29 Vdout0_29ck173 = 0 time = 1740
.meas tran vdout0_29ck173 FIND v(dout0_29) AT=1740.05n

* CHECK dout0_30 Vdout0_30ck173 = 0 time = 1740
.meas tran vdout0_30ck173 FIND v(dout0_30) AT=1740.05n

* CHECK dout0_31 Vdout0_31ck173 = 1.8 time = 1740
.meas tran vdout0_31ck173 FIND v(dout0_31) AT=1740.05n

* CHECK dout1_0 Vdout1_0ck173 = 0 time = 1740
.meas tran vdout1_0ck173 FIND v(dout1_0) AT=1740.05n

* CHECK dout1_1 Vdout1_1ck173 = 1.8 time = 1740
.meas tran vdout1_1ck173 FIND v(dout1_1) AT=1740.05n

* CHECK dout1_2 Vdout1_2ck173 = 1.8 time = 1740
.meas tran vdout1_2ck173 FIND v(dout1_2) AT=1740.05n

* CHECK dout1_3 Vdout1_3ck173 = 1.8 time = 1740
.meas tran vdout1_3ck173 FIND v(dout1_3) AT=1740.05n

* CHECK dout1_4 Vdout1_4ck173 = 1.8 time = 1740
.meas tran vdout1_4ck173 FIND v(dout1_4) AT=1740.05n

* CHECK dout1_5 Vdout1_5ck173 = 0 time = 1740
.meas tran vdout1_5ck173 FIND v(dout1_5) AT=1740.05n

* CHECK dout1_6 Vdout1_6ck173 = 1.8 time = 1740
.meas tran vdout1_6ck173 FIND v(dout1_6) AT=1740.05n

* CHECK dout1_7 Vdout1_7ck173 = 0 time = 1740
.meas tran vdout1_7ck173 FIND v(dout1_7) AT=1740.05n

* CHECK dout1_8 Vdout1_8ck173 = 1.8 time = 1740
.meas tran vdout1_8ck173 FIND v(dout1_8) AT=1740.05n

* CHECK dout1_9 Vdout1_9ck173 = 1.8 time = 1740
.meas tran vdout1_9ck173 FIND v(dout1_9) AT=1740.05n

* CHECK dout1_10 Vdout1_10ck173 = 0 time = 1740
.meas tran vdout1_10ck173 FIND v(dout1_10) AT=1740.05n

* CHECK dout1_11 Vdout1_11ck173 = 1.8 time = 1740
.meas tran vdout1_11ck173 FIND v(dout1_11) AT=1740.05n

* CHECK dout1_12 Vdout1_12ck173 = 1.8 time = 1740
.meas tran vdout1_12ck173 FIND v(dout1_12) AT=1740.05n

* CHECK dout1_13 Vdout1_13ck173 = 1.8 time = 1740
.meas tran vdout1_13ck173 FIND v(dout1_13) AT=1740.05n

* CHECK dout1_14 Vdout1_14ck173 = 0 time = 1740
.meas tran vdout1_14ck173 FIND v(dout1_14) AT=1740.05n

* CHECK dout1_15 Vdout1_15ck173 = 0 time = 1740
.meas tran vdout1_15ck173 FIND v(dout1_15) AT=1740.05n

* CHECK dout1_16 Vdout1_16ck173 = 1.8 time = 1740
.meas tran vdout1_16ck173 FIND v(dout1_16) AT=1740.05n

* CHECK dout1_17 Vdout1_17ck173 = 1.8 time = 1740
.meas tran vdout1_17ck173 FIND v(dout1_17) AT=1740.05n

* CHECK dout1_18 Vdout1_18ck173 = 1.8 time = 1740
.meas tran vdout1_18ck173 FIND v(dout1_18) AT=1740.05n

* CHECK dout1_19 Vdout1_19ck173 = 1.8 time = 1740
.meas tran vdout1_19ck173 FIND v(dout1_19) AT=1740.05n

* CHECK dout1_20 Vdout1_20ck173 = 1.8 time = 1740
.meas tran vdout1_20ck173 FIND v(dout1_20) AT=1740.05n

* CHECK dout1_21 Vdout1_21ck173 = 0 time = 1740
.meas tran vdout1_21ck173 FIND v(dout1_21) AT=1740.05n

* CHECK dout1_22 Vdout1_22ck173 = 1.8 time = 1740
.meas tran vdout1_22ck173 FIND v(dout1_22) AT=1740.05n

* CHECK dout1_23 Vdout1_23ck173 = 1.8 time = 1740
.meas tran vdout1_23ck173 FIND v(dout1_23) AT=1740.05n

* CHECK dout1_24 Vdout1_24ck173 = 1.8 time = 1740
.meas tran vdout1_24ck173 FIND v(dout1_24) AT=1740.05n

* CHECK dout1_25 Vdout1_25ck173 = 1.8 time = 1740
.meas tran vdout1_25ck173 FIND v(dout1_25) AT=1740.05n

* CHECK dout1_26 Vdout1_26ck173 = 1.8 time = 1740
.meas tran vdout1_26ck173 FIND v(dout1_26) AT=1740.05n

* CHECK dout1_27 Vdout1_27ck173 = 1.8 time = 1740
.meas tran vdout1_27ck173 FIND v(dout1_27) AT=1740.05n

* CHECK dout1_28 Vdout1_28ck173 = 0 time = 1740
.meas tran vdout1_28ck173 FIND v(dout1_28) AT=1740.05n

* CHECK dout1_29 Vdout1_29ck173 = 0 time = 1740
.meas tran vdout1_29ck173 FIND v(dout1_29) AT=1740.05n

* CHECK dout1_30 Vdout1_30ck173 = 0 time = 1740
.meas tran vdout1_30ck173 FIND v(dout1_30) AT=1740.05n

* CHECK dout1_31 Vdout1_31ck173 = 0 time = 1740
.meas tran vdout1_31ck173 FIND v(dout1_31) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck175 = 0 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 0 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 1.8 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 0 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 1760
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=1760.05n

* CHECK dout0_9 Vdout0_9ck175 = 1.8 time = 1760
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=1760.05n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 1760
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=1760.05n

* CHECK dout0_11 Vdout0_11ck175 = 0 time = 1760
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=1760.05n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 1760
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=1760.05n

* CHECK dout0_13 Vdout0_13ck175 = 1.8 time = 1760
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=1760.05n

* CHECK dout0_14 Vdout0_14ck175 = 0 time = 1760
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=1760.05n

* CHECK dout0_15 Vdout0_15ck175 = 0 time = 1760
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=1760.05n

* CHECK dout0_16 Vdout0_16ck175 = 1.8 time = 1760
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=1760.05n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 1760
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=1760.05n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 1760
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=1760.05n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 1760
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=1760.05n

* CHECK dout0_20 Vdout0_20ck175 = 0 time = 1760
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=1760.05n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 1760
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=1760.05n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 1760
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=1760.05n

* CHECK dout0_23 Vdout0_23ck175 = 0 time = 1760
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=1760.05n

* CHECK dout0_24 Vdout0_24ck175 = 1.8 time = 1760
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=1760.05n

* CHECK dout0_25 Vdout0_25ck175 = 1.8 time = 1760
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=1760.05n

* CHECK dout0_26 Vdout0_26ck175 = 1.8 time = 1760
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=1760.05n

* CHECK dout0_27 Vdout0_27ck175 = 0 time = 1760
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=1760.05n

* CHECK dout0_28 Vdout0_28ck175 = 0 time = 1760
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=1760.05n

* CHECK dout0_29 Vdout0_29ck175 = 0 time = 1760
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=1760.05n

* CHECK dout0_30 Vdout0_30ck175 = 0 time = 1760
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=1760.05n

* CHECK dout0_31 Vdout0_31ck175 = 1.8 time = 1760
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 1790
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=1790.05n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 1790
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=1790.05n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 1790
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=1790.05n

* CHECK dout0_3 Vdout0_3ck178 = 0 time = 1790
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=1790.05n

* CHECK dout0_4 Vdout0_4ck178 = 1.8 time = 1790
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=1790.05n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 1790
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=1790.05n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 1790
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=1790.05n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 1790
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=1790.05n

* CHECK dout0_8 Vdout0_8ck178 = 0 time = 1790
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=1790.05n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 1790
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=1790.05n

* CHECK dout0_10 Vdout0_10ck178 = 1.8 time = 1790
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=1790.05n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 1790
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=1790.05n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 1790
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=1790.05n

* CHECK dout0_13 Vdout0_13ck178 = 1.8 time = 1790
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=1790.05n

* CHECK dout0_14 Vdout0_14ck178 = 0 time = 1790
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=1790.05n

* CHECK dout0_15 Vdout0_15ck178 = 0 time = 1790
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=1790.05n

* CHECK dout0_16 Vdout0_16ck178 = 1.8 time = 1790
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=1790.05n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 1790
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=1790.05n

* CHECK dout0_18 Vdout0_18ck178 = 1.8 time = 1790
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=1790.05n

* CHECK dout0_19 Vdout0_19ck178 = 0 time = 1790
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=1790.05n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 1790
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=1790.05n

* CHECK dout0_21 Vdout0_21ck178 = 1.8 time = 1790
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=1790.05n

* CHECK dout0_22 Vdout0_22ck178 = 0 time = 1790
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=1790.05n

* CHECK dout0_23 Vdout0_23ck178 = 0 time = 1790
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=1790.05n

* CHECK dout0_24 Vdout0_24ck178 = 1.8 time = 1790
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=1790.05n

* CHECK dout0_25 Vdout0_25ck178 = 1.8 time = 1790
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=1790.05n

* CHECK dout0_26 Vdout0_26ck178 = 1.8 time = 1790
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=1790.05n

* CHECK dout0_27 Vdout0_27ck178 = 0 time = 1790
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=1790.05n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 1790
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=1790.05n

* CHECK dout0_29 Vdout0_29ck178 = 0 time = 1790
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=1790.05n

* CHECK dout0_30 Vdout0_30ck178 = 0 time = 1790
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=1790.05n

* CHECK dout0_31 Vdout0_31ck178 = 1.8 time = 1790
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=1790.05n

* CHECK dout1_0 Vdout1_0ck178 = 0 time = 1790
.meas tran vdout1_0ck178 FIND v(dout1_0) AT=1790.05n

* CHECK dout1_1 Vdout1_1ck178 = 0 time = 1790
.meas tran vdout1_1ck178 FIND v(dout1_1) AT=1790.05n

* CHECK dout1_2 Vdout1_2ck178 = 1.8 time = 1790
.meas tran vdout1_2ck178 FIND v(dout1_2) AT=1790.05n

* CHECK dout1_3 Vdout1_3ck178 = 0 time = 1790
.meas tran vdout1_3ck178 FIND v(dout1_3) AT=1790.05n

* CHECK dout1_4 Vdout1_4ck178 = 0 time = 1790
.meas tran vdout1_4ck178 FIND v(dout1_4) AT=1790.05n

* CHECK dout1_5 Vdout1_5ck178 = 1.8 time = 1790
.meas tran vdout1_5ck178 FIND v(dout1_5) AT=1790.05n

* CHECK dout1_6 Vdout1_6ck178 = 1.8 time = 1790
.meas tran vdout1_6ck178 FIND v(dout1_6) AT=1790.05n

* CHECK dout1_7 Vdout1_7ck178 = 0 time = 1790
.meas tran vdout1_7ck178 FIND v(dout1_7) AT=1790.05n

* CHECK dout1_8 Vdout1_8ck178 = 0 time = 1790
.meas tran vdout1_8ck178 FIND v(dout1_8) AT=1790.05n

* CHECK dout1_9 Vdout1_9ck178 = 1.8 time = 1790
.meas tran vdout1_9ck178 FIND v(dout1_9) AT=1790.05n

* CHECK dout1_10 Vdout1_10ck178 = 0 time = 1790
.meas tran vdout1_10ck178 FIND v(dout1_10) AT=1790.05n

* CHECK dout1_11 Vdout1_11ck178 = 0 time = 1790
.meas tran vdout1_11ck178 FIND v(dout1_11) AT=1790.05n

* CHECK dout1_12 Vdout1_12ck178 = 1.8 time = 1790
.meas tran vdout1_12ck178 FIND v(dout1_12) AT=1790.05n

* CHECK dout1_13 Vdout1_13ck178 = 1.8 time = 1790
.meas tran vdout1_13ck178 FIND v(dout1_13) AT=1790.05n

* CHECK dout1_14 Vdout1_14ck178 = 0 time = 1790
.meas tran vdout1_14ck178 FIND v(dout1_14) AT=1790.05n

* CHECK dout1_15 Vdout1_15ck178 = 1.8 time = 1790
.meas tran vdout1_15ck178 FIND v(dout1_15) AT=1790.05n

* CHECK dout1_16 Vdout1_16ck178 = 1.8 time = 1790
.meas tran vdout1_16ck178 FIND v(dout1_16) AT=1790.05n

* CHECK dout1_17 Vdout1_17ck178 = 1.8 time = 1790
.meas tran vdout1_17ck178 FIND v(dout1_17) AT=1790.05n

* CHECK dout1_18 Vdout1_18ck178 = 0 time = 1790
.meas tran vdout1_18ck178 FIND v(dout1_18) AT=1790.05n

* CHECK dout1_19 Vdout1_19ck178 = 0 time = 1790
.meas tran vdout1_19ck178 FIND v(dout1_19) AT=1790.05n

* CHECK dout1_20 Vdout1_20ck178 = 0 time = 1790
.meas tran vdout1_20ck178 FIND v(dout1_20) AT=1790.05n

* CHECK dout1_21 Vdout1_21ck178 = 1.8 time = 1790
.meas tran vdout1_21ck178 FIND v(dout1_21) AT=1790.05n

* CHECK dout1_22 Vdout1_22ck178 = 1.8 time = 1790
.meas tran vdout1_22ck178 FIND v(dout1_22) AT=1790.05n

* CHECK dout1_23 Vdout1_23ck178 = 0 time = 1790
.meas tran vdout1_23ck178 FIND v(dout1_23) AT=1790.05n

* CHECK dout1_24 Vdout1_24ck178 = 1.8 time = 1790
.meas tran vdout1_24ck178 FIND v(dout1_24) AT=1790.05n

* CHECK dout1_25 Vdout1_25ck178 = 0 time = 1790
.meas tran vdout1_25ck178 FIND v(dout1_25) AT=1790.05n

* CHECK dout1_26 Vdout1_26ck178 = 1.8 time = 1790
.meas tran vdout1_26ck178 FIND v(dout1_26) AT=1790.05n

* CHECK dout1_27 Vdout1_27ck178 = 0 time = 1790
.meas tran vdout1_27ck178 FIND v(dout1_27) AT=1790.05n

* CHECK dout1_28 Vdout1_28ck178 = 0 time = 1790
.meas tran vdout1_28ck178 FIND v(dout1_28) AT=1790.05n

* CHECK dout1_29 Vdout1_29ck178 = 1.8 time = 1790
.meas tran vdout1_29ck178 FIND v(dout1_29) AT=1790.05n

* CHECK dout1_30 Vdout1_30ck178 = 1.8 time = 1790
.meas tran vdout1_30ck178 FIND v(dout1_30) AT=1790.05n

* CHECK dout1_31 Vdout1_31ck178 = 1.8 time = 1790
.meas tran vdout1_31ck178 FIND v(dout1_31) AT=1790.05n

* CHECK dout0_0 Vdout0_0ck179 = 0 time = 1800
.meas tran vdout0_0ck179 FIND v(dout0_0) AT=1800.05n

* CHECK dout0_1 Vdout0_1ck179 = 1.8 time = 1800
.meas tran vdout0_1ck179 FIND v(dout0_1) AT=1800.05n

* CHECK dout0_2 Vdout0_2ck179 = 1.8 time = 1800
.meas tran vdout0_2ck179 FIND v(dout0_2) AT=1800.05n

* CHECK dout0_3 Vdout0_3ck179 = 1.8 time = 1800
.meas tran vdout0_3ck179 FIND v(dout0_3) AT=1800.05n

* CHECK dout0_4 Vdout0_4ck179 = 1.8 time = 1800
.meas tran vdout0_4ck179 FIND v(dout0_4) AT=1800.05n

* CHECK dout0_5 Vdout0_5ck179 = 0 time = 1800
.meas tran vdout0_5ck179 FIND v(dout0_5) AT=1800.05n

* CHECK dout0_6 Vdout0_6ck179 = 1.8 time = 1800
.meas tran vdout0_6ck179 FIND v(dout0_6) AT=1800.05n

* CHECK dout0_7 Vdout0_7ck179 = 0 time = 1800
.meas tran vdout0_7ck179 FIND v(dout0_7) AT=1800.05n

* CHECK dout0_8 Vdout0_8ck179 = 1.8 time = 1800
.meas tran vdout0_8ck179 FIND v(dout0_8) AT=1800.05n

* CHECK dout0_9 Vdout0_9ck179 = 1.8 time = 1800
.meas tran vdout0_9ck179 FIND v(dout0_9) AT=1800.05n

* CHECK dout0_10 Vdout0_10ck179 = 0 time = 1800
.meas tran vdout0_10ck179 FIND v(dout0_10) AT=1800.05n

* CHECK dout0_11 Vdout0_11ck179 = 1.8 time = 1800
.meas tran vdout0_11ck179 FIND v(dout0_11) AT=1800.05n

* CHECK dout0_12 Vdout0_12ck179 = 1.8 time = 1800
.meas tran vdout0_12ck179 FIND v(dout0_12) AT=1800.05n

* CHECK dout0_13 Vdout0_13ck179 = 1.8 time = 1800
.meas tran vdout0_13ck179 FIND v(dout0_13) AT=1800.05n

* CHECK dout0_14 Vdout0_14ck179 = 0 time = 1800
.meas tran vdout0_14ck179 FIND v(dout0_14) AT=1800.05n

* CHECK dout0_15 Vdout0_15ck179 = 0 time = 1800
.meas tran vdout0_15ck179 FIND v(dout0_15) AT=1800.05n

* CHECK dout0_16 Vdout0_16ck179 = 1.8 time = 1800
.meas tran vdout0_16ck179 FIND v(dout0_16) AT=1800.05n

* CHECK dout0_17 Vdout0_17ck179 = 1.8 time = 1800
.meas tran vdout0_17ck179 FIND v(dout0_17) AT=1800.05n

* CHECK dout0_18 Vdout0_18ck179 = 1.8 time = 1800
.meas tran vdout0_18ck179 FIND v(dout0_18) AT=1800.05n

* CHECK dout0_19 Vdout0_19ck179 = 1.8 time = 1800
.meas tran vdout0_19ck179 FIND v(dout0_19) AT=1800.05n

* CHECK dout0_20 Vdout0_20ck179 = 1.8 time = 1800
.meas tran vdout0_20ck179 FIND v(dout0_20) AT=1800.05n

* CHECK dout0_21 Vdout0_21ck179 = 0 time = 1800
.meas tran vdout0_21ck179 FIND v(dout0_21) AT=1800.05n

* CHECK dout0_22 Vdout0_22ck179 = 1.8 time = 1800
.meas tran vdout0_22ck179 FIND v(dout0_22) AT=1800.05n

* CHECK dout0_23 Vdout0_23ck179 = 1.8 time = 1800
.meas tran vdout0_23ck179 FIND v(dout0_23) AT=1800.05n

* CHECK dout0_24 Vdout0_24ck179 = 1.8 time = 1800
.meas tran vdout0_24ck179 FIND v(dout0_24) AT=1800.05n

* CHECK dout0_25 Vdout0_25ck179 = 1.8 time = 1800
.meas tran vdout0_25ck179 FIND v(dout0_25) AT=1800.05n

* CHECK dout0_26 Vdout0_26ck179 = 1.8 time = 1800
.meas tran vdout0_26ck179 FIND v(dout0_26) AT=1800.05n

* CHECK dout0_27 Vdout0_27ck179 = 1.8 time = 1800
.meas tran vdout0_27ck179 FIND v(dout0_27) AT=1800.05n

* CHECK dout0_28 Vdout0_28ck179 = 0 time = 1800
.meas tran vdout0_28ck179 FIND v(dout0_28) AT=1800.05n

* CHECK dout0_29 Vdout0_29ck179 = 0 time = 1800
.meas tran vdout0_29ck179 FIND v(dout0_29) AT=1800.05n

* CHECK dout0_30 Vdout0_30ck179 = 0 time = 1800
.meas tran vdout0_30ck179 FIND v(dout0_30) AT=1800.05n

* CHECK dout0_31 Vdout0_31ck179 = 0 time = 1800
.meas tran vdout0_31ck179 FIND v(dout0_31) AT=1800.05n

* CHECK dout0_0 Vdout0_0ck180 = 0 time = 1810
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=1810.05n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 1810
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=1810.05n

* CHECK dout0_2 Vdout0_2ck180 = 1.8 time = 1810
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=1810.05n

* CHECK dout0_3 Vdout0_3ck180 = 0 time = 1810
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=1810.05n

* CHECK dout0_4 Vdout0_4ck180 = 0 time = 1810
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=1810.05n

* CHECK dout0_5 Vdout0_5ck180 = 1.8 time = 1810
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=1810.05n

* CHECK dout0_6 Vdout0_6ck180 = 1.8 time = 1810
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=1810.05n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 1810
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=1810.05n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 1810
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=1810.05n

* CHECK dout0_9 Vdout0_9ck180 = 1.8 time = 1810
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=1810.05n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 1810
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=1810.05n

* CHECK dout0_11 Vdout0_11ck180 = 0 time = 1810
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=1810.05n

* CHECK dout0_12 Vdout0_12ck180 = 1.8 time = 1810
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=1810.05n

* CHECK dout0_13 Vdout0_13ck180 = 1.8 time = 1810
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=1810.05n

* CHECK dout0_14 Vdout0_14ck180 = 0 time = 1810
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=1810.05n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 1810
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=1810.05n

* CHECK dout0_16 Vdout0_16ck180 = 1.8 time = 1810
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=1810.05n

* CHECK dout0_17 Vdout0_17ck180 = 1.8 time = 1810
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=1810.05n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 1810
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=1810.05n

* CHECK dout0_19 Vdout0_19ck180 = 0 time = 1810
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=1810.05n

* CHECK dout0_20 Vdout0_20ck180 = 0 time = 1810
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=1810.05n

* CHECK dout0_21 Vdout0_21ck180 = 1.8 time = 1810
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=1810.05n

* CHECK dout0_22 Vdout0_22ck180 = 1.8 time = 1810
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=1810.05n

* CHECK dout0_23 Vdout0_23ck180 = 0 time = 1810
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=1810.05n

* CHECK dout0_24 Vdout0_24ck180 = 1.8 time = 1810
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=1810.05n

* CHECK dout0_25 Vdout0_25ck180 = 0 time = 1810
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=1810.05n

* CHECK dout0_26 Vdout0_26ck180 = 1.8 time = 1810
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=1810.05n

* CHECK dout0_27 Vdout0_27ck180 = 0 time = 1810
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=1810.05n

* CHECK dout0_28 Vdout0_28ck180 = 0 time = 1810
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=1810.05n

* CHECK dout0_29 Vdout0_29ck180 = 1.8 time = 1810
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=1810.05n

* CHECK dout0_30 Vdout0_30ck180 = 1.8 time = 1810
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=1810.05n

* CHECK dout0_31 Vdout0_31ck180 = 1.8 time = 1810
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=1810.05n

* CHECK dout1_0 Vdout1_0ck180 = 0 time = 1810
.meas tran vdout1_0ck180 FIND v(dout1_0) AT=1810.05n

* CHECK dout1_1 Vdout1_1ck180 = 1.8 time = 1810
.meas tran vdout1_1ck180 FIND v(dout1_1) AT=1810.05n

* CHECK dout1_2 Vdout1_2ck180 = 1.8 time = 1810
.meas tran vdout1_2ck180 FIND v(dout1_2) AT=1810.05n

* CHECK dout1_3 Vdout1_3ck180 = 1.8 time = 1810
.meas tran vdout1_3ck180 FIND v(dout1_3) AT=1810.05n

* CHECK dout1_4 Vdout1_4ck180 = 1.8 time = 1810
.meas tran vdout1_4ck180 FIND v(dout1_4) AT=1810.05n

* CHECK dout1_5 Vdout1_5ck180 = 0 time = 1810
.meas tran vdout1_5ck180 FIND v(dout1_5) AT=1810.05n

* CHECK dout1_6 Vdout1_6ck180 = 1.8 time = 1810
.meas tran vdout1_6ck180 FIND v(dout1_6) AT=1810.05n

* CHECK dout1_7 Vdout1_7ck180 = 0 time = 1810
.meas tran vdout1_7ck180 FIND v(dout1_7) AT=1810.05n

* CHECK dout1_8 Vdout1_8ck180 = 1.8 time = 1810
.meas tran vdout1_8ck180 FIND v(dout1_8) AT=1810.05n

* CHECK dout1_9 Vdout1_9ck180 = 1.8 time = 1810
.meas tran vdout1_9ck180 FIND v(dout1_9) AT=1810.05n

* CHECK dout1_10 Vdout1_10ck180 = 0 time = 1810
.meas tran vdout1_10ck180 FIND v(dout1_10) AT=1810.05n

* CHECK dout1_11 Vdout1_11ck180 = 1.8 time = 1810
.meas tran vdout1_11ck180 FIND v(dout1_11) AT=1810.05n

* CHECK dout1_12 Vdout1_12ck180 = 1.8 time = 1810
.meas tran vdout1_12ck180 FIND v(dout1_12) AT=1810.05n

* CHECK dout1_13 Vdout1_13ck180 = 1.8 time = 1810
.meas tran vdout1_13ck180 FIND v(dout1_13) AT=1810.05n

* CHECK dout1_14 Vdout1_14ck180 = 0 time = 1810
.meas tran vdout1_14ck180 FIND v(dout1_14) AT=1810.05n

* CHECK dout1_15 Vdout1_15ck180 = 0 time = 1810
.meas tran vdout1_15ck180 FIND v(dout1_15) AT=1810.05n

* CHECK dout1_16 Vdout1_16ck180 = 1.8 time = 1810
.meas tran vdout1_16ck180 FIND v(dout1_16) AT=1810.05n

* CHECK dout1_17 Vdout1_17ck180 = 1.8 time = 1810
.meas tran vdout1_17ck180 FIND v(dout1_17) AT=1810.05n

* CHECK dout1_18 Vdout1_18ck180 = 1.8 time = 1810
.meas tran vdout1_18ck180 FIND v(dout1_18) AT=1810.05n

* CHECK dout1_19 Vdout1_19ck180 = 1.8 time = 1810
.meas tran vdout1_19ck180 FIND v(dout1_19) AT=1810.05n

* CHECK dout1_20 Vdout1_20ck180 = 1.8 time = 1810
.meas tran vdout1_20ck180 FIND v(dout1_20) AT=1810.05n

* CHECK dout1_21 Vdout1_21ck180 = 0 time = 1810
.meas tran vdout1_21ck180 FIND v(dout1_21) AT=1810.05n

* CHECK dout1_22 Vdout1_22ck180 = 1.8 time = 1810
.meas tran vdout1_22ck180 FIND v(dout1_22) AT=1810.05n

* CHECK dout1_23 Vdout1_23ck180 = 1.8 time = 1810
.meas tran vdout1_23ck180 FIND v(dout1_23) AT=1810.05n

* CHECK dout1_24 Vdout1_24ck180 = 1.8 time = 1810
.meas tran vdout1_24ck180 FIND v(dout1_24) AT=1810.05n

* CHECK dout1_25 Vdout1_25ck180 = 1.8 time = 1810
.meas tran vdout1_25ck180 FIND v(dout1_25) AT=1810.05n

* CHECK dout1_26 Vdout1_26ck180 = 1.8 time = 1810
.meas tran vdout1_26ck180 FIND v(dout1_26) AT=1810.05n

* CHECK dout1_27 Vdout1_27ck180 = 1.8 time = 1810
.meas tran vdout1_27ck180 FIND v(dout1_27) AT=1810.05n

* CHECK dout1_28 Vdout1_28ck180 = 0 time = 1810
.meas tran vdout1_28ck180 FIND v(dout1_28) AT=1810.05n

* CHECK dout1_29 Vdout1_29ck180 = 0 time = 1810
.meas tran vdout1_29ck180 FIND v(dout1_29) AT=1810.05n

* CHECK dout1_30 Vdout1_30ck180 = 0 time = 1810
.meas tran vdout1_30ck180 FIND v(dout1_30) AT=1810.05n

* CHECK dout1_31 Vdout1_31ck180 = 0 time = 1810
.meas tran vdout1_31ck180 FIND v(dout1_31) AT=1810.05n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 1820
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=1820.05n

* CHECK dout0_1 Vdout0_1ck181 = 1.8 time = 1820
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=1820.05n

* CHECK dout0_2 Vdout0_2ck181 = 1.8 time = 1820
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=1820.05n

* CHECK dout0_3 Vdout0_3ck181 = 1.8 time = 1820
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=1820.05n

* CHECK dout0_4 Vdout0_4ck181 = 1.8 time = 1820
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=1820.05n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 1820
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=1820.05n

* CHECK dout0_6 Vdout0_6ck181 = 1.8 time = 1820
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=1820.05n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 1820
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=1820.05n

* CHECK dout0_8 Vdout0_8ck181 = 1.8 time = 1820
.meas tran vdout0_8ck181 FIND v(dout0_8) AT=1820.05n

* CHECK dout0_9 Vdout0_9ck181 = 1.8 time = 1820
.meas tran vdout0_9ck181 FIND v(dout0_9) AT=1820.05n

* CHECK dout0_10 Vdout0_10ck181 = 0 time = 1820
.meas tran vdout0_10ck181 FIND v(dout0_10) AT=1820.05n

* CHECK dout0_11 Vdout0_11ck181 = 1.8 time = 1820
.meas tran vdout0_11ck181 FIND v(dout0_11) AT=1820.05n

* CHECK dout0_12 Vdout0_12ck181 = 1.8 time = 1820
.meas tran vdout0_12ck181 FIND v(dout0_12) AT=1820.05n

* CHECK dout0_13 Vdout0_13ck181 = 1.8 time = 1820
.meas tran vdout0_13ck181 FIND v(dout0_13) AT=1820.05n

* CHECK dout0_14 Vdout0_14ck181 = 0 time = 1820
.meas tran vdout0_14ck181 FIND v(dout0_14) AT=1820.05n

* CHECK dout0_15 Vdout0_15ck181 = 0 time = 1820
.meas tran vdout0_15ck181 FIND v(dout0_15) AT=1820.05n

* CHECK dout0_16 Vdout0_16ck181 = 1.8 time = 1820
.meas tran vdout0_16ck181 FIND v(dout0_16) AT=1820.05n

* CHECK dout0_17 Vdout0_17ck181 = 1.8 time = 1820
.meas tran vdout0_17ck181 FIND v(dout0_17) AT=1820.05n

* CHECK dout0_18 Vdout0_18ck181 = 1.8 time = 1820
.meas tran vdout0_18ck181 FIND v(dout0_18) AT=1820.05n

* CHECK dout0_19 Vdout0_19ck181 = 1.8 time = 1820
.meas tran vdout0_19ck181 FIND v(dout0_19) AT=1820.05n

* CHECK dout0_20 Vdout0_20ck181 = 1.8 time = 1820
.meas tran vdout0_20ck181 FIND v(dout0_20) AT=1820.05n

* CHECK dout0_21 Vdout0_21ck181 = 0 time = 1820
.meas tran vdout0_21ck181 FIND v(dout0_21) AT=1820.05n

* CHECK dout0_22 Vdout0_22ck181 = 1.8 time = 1820
.meas tran vdout0_22ck181 FIND v(dout0_22) AT=1820.05n

* CHECK dout0_23 Vdout0_23ck181 = 1.8 time = 1820
.meas tran vdout0_23ck181 FIND v(dout0_23) AT=1820.05n

* CHECK dout0_24 Vdout0_24ck181 = 1.8 time = 1820
.meas tran vdout0_24ck181 FIND v(dout0_24) AT=1820.05n

* CHECK dout0_25 Vdout0_25ck181 = 1.8 time = 1820
.meas tran vdout0_25ck181 FIND v(dout0_25) AT=1820.05n

* CHECK dout0_26 Vdout0_26ck181 = 1.8 time = 1820
.meas tran vdout0_26ck181 FIND v(dout0_26) AT=1820.05n

* CHECK dout0_27 Vdout0_27ck181 = 1.8 time = 1820
.meas tran vdout0_27ck181 FIND v(dout0_27) AT=1820.05n

* CHECK dout0_28 Vdout0_28ck181 = 0 time = 1820
.meas tran vdout0_28ck181 FIND v(dout0_28) AT=1820.05n

* CHECK dout0_29 Vdout0_29ck181 = 0 time = 1820
.meas tran vdout0_29ck181 FIND v(dout0_29) AT=1820.05n

* CHECK dout0_30 Vdout0_30ck181 = 0 time = 1820
.meas tran vdout0_30ck181 FIND v(dout0_30) AT=1820.05n

* CHECK dout0_31 Vdout0_31ck181 = 0 time = 1820
.meas tran vdout0_31ck181 FIND v(dout0_31) AT=1820.05n

* CHECK dout1_0 Vdout1_0ck181 = 0 time = 1820
.meas tran vdout1_0ck181 FIND v(dout1_0) AT=1820.05n

* CHECK dout1_1 Vdout1_1ck181 = 0 time = 1820
.meas tran vdout1_1ck181 FIND v(dout1_1) AT=1820.05n

* CHECK dout1_2 Vdout1_2ck181 = 0 time = 1820
.meas tran vdout1_2ck181 FIND v(dout1_2) AT=1820.05n

* CHECK dout1_3 Vdout1_3ck181 = 0 time = 1820
.meas tran vdout1_3ck181 FIND v(dout1_3) AT=1820.05n

* CHECK dout1_4 Vdout1_4ck181 = 1.8 time = 1820
.meas tran vdout1_4ck181 FIND v(dout1_4) AT=1820.05n

* CHECK dout1_5 Vdout1_5ck181 = 0 time = 1820
.meas tran vdout1_5ck181 FIND v(dout1_5) AT=1820.05n

* CHECK dout1_6 Vdout1_6ck181 = 0 time = 1820
.meas tran vdout1_6ck181 FIND v(dout1_6) AT=1820.05n

* CHECK dout1_7 Vdout1_7ck181 = 0 time = 1820
.meas tran vdout1_7ck181 FIND v(dout1_7) AT=1820.05n

* CHECK dout1_8 Vdout1_8ck181 = 0 time = 1820
.meas tran vdout1_8ck181 FIND v(dout1_8) AT=1820.05n

* CHECK dout1_9 Vdout1_9ck181 = 1.8 time = 1820
.meas tran vdout1_9ck181 FIND v(dout1_9) AT=1820.05n

* CHECK dout1_10 Vdout1_10ck181 = 1.8 time = 1820
.meas tran vdout1_10ck181 FIND v(dout1_10) AT=1820.05n

* CHECK dout1_11 Vdout1_11ck181 = 0 time = 1820
.meas tran vdout1_11ck181 FIND v(dout1_11) AT=1820.05n

* CHECK dout1_12 Vdout1_12ck181 = 0 time = 1820
.meas tran vdout1_12ck181 FIND v(dout1_12) AT=1820.05n

* CHECK dout1_13 Vdout1_13ck181 = 1.8 time = 1820
.meas tran vdout1_13ck181 FIND v(dout1_13) AT=1820.05n

* CHECK dout1_14 Vdout1_14ck181 = 0 time = 1820
.meas tran vdout1_14ck181 FIND v(dout1_14) AT=1820.05n

* CHECK dout1_15 Vdout1_15ck181 = 0 time = 1820
.meas tran vdout1_15ck181 FIND v(dout1_15) AT=1820.05n

* CHECK dout1_16 Vdout1_16ck181 = 1.8 time = 1820
.meas tran vdout1_16ck181 FIND v(dout1_16) AT=1820.05n

* CHECK dout1_17 Vdout1_17ck181 = 0 time = 1820
.meas tran vdout1_17ck181 FIND v(dout1_17) AT=1820.05n

* CHECK dout1_18 Vdout1_18ck181 = 1.8 time = 1820
.meas tran vdout1_18ck181 FIND v(dout1_18) AT=1820.05n

* CHECK dout1_19 Vdout1_19ck181 = 0 time = 1820
.meas tran vdout1_19ck181 FIND v(dout1_19) AT=1820.05n

* CHECK dout1_20 Vdout1_20ck181 = 0 time = 1820
.meas tran vdout1_20ck181 FIND v(dout1_20) AT=1820.05n

* CHECK dout1_21 Vdout1_21ck181 = 1.8 time = 1820
.meas tran vdout1_21ck181 FIND v(dout1_21) AT=1820.05n

* CHECK dout1_22 Vdout1_22ck181 = 0 time = 1820
.meas tran vdout1_22ck181 FIND v(dout1_22) AT=1820.05n

* CHECK dout1_23 Vdout1_23ck181 = 0 time = 1820
.meas tran vdout1_23ck181 FIND v(dout1_23) AT=1820.05n

* CHECK dout1_24 Vdout1_24ck181 = 1.8 time = 1820
.meas tran vdout1_24ck181 FIND v(dout1_24) AT=1820.05n

* CHECK dout1_25 Vdout1_25ck181 = 1.8 time = 1820
.meas tran vdout1_25ck181 FIND v(dout1_25) AT=1820.05n

* CHECK dout1_26 Vdout1_26ck181 = 1.8 time = 1820
.meas tran vdout1_26ck181 FIND v(dout1_26) AT=1820.05n

* CHECK dout1_27 Vdout1_27ck181 = 0 time = 1820
.meas tran vdout1_27ck181 FIND v(dout1_27) AT=1820.05n

* CHECK dout1_28 Vdout1_28ck181 = 0 time = 1820
.meas tran vdout1_28ck181 FIND v(dout1_28) AT=1820.05n

* CHECK dout1_29 Vdout1_29ck181 = 0 time = 1820
.meas tran vdout1_29ck181 FIND v(dout1_29) AT=1820.05n

* CHECK dout1_30 Vdout1_30ck181 = 0 time = 1820
.meas tran vdout1_30ck181 FIND v(dout1_30) AT=1820.05n

* CHECK dout1_31 Vdout1_31ck181 = 1.8 time = 1820
.meas tran vdout1_31ck181 FIND v(dout1_31) AT=1820.05n

* CHECK dout1_0 Vdout1_0ck182 = 0 time = 1830
.meas tran vdout1_0ck182 FIND v(dout1_0) AT=1830.05n

* CHECK dout1_1 Vdout1_1ck182 = 0 time = 1830
.meas tran vdout1_1ck182 FIND v(dout1_1) AT=1830.05n

* CHECK dout1_2 Vdout1_2ck182 = 1.8 time = 1830
.meas tran vdout1_2ck182 FIND v(dout1_2) AT=1830.05n

* CHECK dout1_3 Vdout1_3ck182 = 0 time = 1830
.meas tran vdout1_3ck182 FIND v(dout1_3) AT=1830.05n

* CHECK dout1_4 Vdout1_4ck182 = 0 time = 1830
.meas tran vdout1_4ck182 FIND v(dout1_4) AT=1830.05n

* CHECK dout1_5 Vdout1_5ck182 = 1.8 time = 1830
.meas tran vdout1_5ck182 FIND v(dout1_5) AT=1830.05n

* CHECK dout1_6 Vdout1_6ck182 = 1.8 time = 1830
.meas tran vdout1_6ck182 FIND v(dout1_6) AT=1830.05n

* CHECK dout1_7 Vdout1_7ck182 = 0 time = 1830
.meas tran vdout1_7ck182 FIND v(dout1_7) AT=1830.05n

* CHECK dout1_8 Vdout1_8ck182 = 0 time = 1830
.meas tran vdout1_8ck182 FIND v(dout1_8) AT=1830.05n

* CHECK dout1_9 Vdout1_9ck182 = 1.8 time = 1830
.meas tran vdout1_9ck182 FIND v(dout1_9) AT=1830.05n

* CHECK dout1_10 Vdout1_10ck182 = 0 time = 1830
.meas tran vdout1_10ck182 FIND v(dout1_10) AT=1830.05n

* CHECK dout1_11 Vdout1_11ck182 = 0 time = 1830
.meas tran vdout1_11ck182 FIND v(dout1_11) AT=1830.05n

* CHECK dout1_12 Vdout1_12ck182 = 1.8 time = 1830
.meas tran vdout1_12ck182 FIND v(dout1_12) AT=1830.05n

* CHECK dout1_13 Vdout1_13ck182 = 1.8 time = 1830
.meas tran vdout1_13ck182 FIND v(dout1_13) AT=1830.05n

* CHECK dout1_14 Vdout1_14ck182 = 0 time = 1830
.meas tran vdout1_14ck182 FIND v(dout1_14) AT=1830.05n

* CHECK dout1_15 Vdout1_15ck182 = 1.8 time = 1830
.meas tran vdout1_15ck182 FIND v(dout1_15) AT=1830.05n

* CHECK dout1_16 Vdout1_16ck182 = 1.8 time = 1830
.meas tran vdout1_16ck182 FIND v(dout1_16) AT=1830.05n

* CHECK dout1_17 Vdout1_17ck182 = 1.8 time = 1830
.meas tran vdout1_17ck182 FIND v(dout1_17) AT=1830.05n

* CHECK dout1_18 Vdout1_18ck182 = 0 time = 1830
.meas tran vdout1_18ck182 FIND v(dout1_18) AT=1830.05n

* CHECK dout1_19 Vdout1_19ck182 = 0 time = 1830
.meas tran vdout1_19ck182 FIND v(dout1_19) AT=1830.05n

* CHECK dout1_20 Vdout1_20ck182 = 0 time = 1830
.meas tran vdout1_20ck182 FIND v(dout1_20) AT=1830.05n

* CHECK dout1_21 Vdout1_21ck182 = 1.8 time = 1830
.meas tran vdout1_21ck182 FIND v(dout1_21) AT=1830.05n

* CHECK dout1_22 Vdout1_22ck182 = 1.8 time = 1830
.meas tran vdout1_22ck182 FIND v(dout1_22) AT=1830.05n

* CHECK dout1_23 Vdout1_23ck182 = 0 time = 1830
.meas tran vdout1_23ck182 FIND v(dout1_23) AT=1830.05n

* CHECK dout1_24 Vdout1_24ck182 = 1.8 time = 1830
.meas tran vdout1_24ck182 FIND v(dout1_24) AT=1830.05n

* CHECK dout1_25 Vdout1_25ck182 = 0 time = 1830
.meas tran vdout1_25ck182 FIND v(dout1_25) AT=1830.05n

* CHECK dout1_26 Vdout1_26ck182 = 1.8 time = 1830
.meas tran vdout1_26ck182 FIND v(dout1_26) AT=1830.05n

* CHECK dout1_27 Vdout1_27ck182 = 0 time = 1830
.meas tran vdout1_27ck182 FIND v(dout1_27) AT=1830.05n

* CHECK dout1_28 Vdout1_28ck182 = 0 time = 1830
.meas tran vdout1_28ck182 FIND v(dout1_28) AT=1830.05n

* CHECK dout1_29 Vdout1_29ck182 = 1.8 time = 1830
.meas tran vdout1_29ck182 FIND v(dout1_29) AT=1830.05n

* CHECK dout1_30 Vdout1_30ck182 = 1.8 time = 1830
.meas tran vdout1_30ck182 FIND v(dout1_30) AT=1830.05n

* CHECK dout1_31 Vdout1_31ck182 = 1.8 time = 1830
.meas tran vdout1_31ck182 FIND v(dout1_31) AT=1830.05n

* CHECK dout0_0 Vdout0_0ck183 = 0 time = 1840
.meas tran vdout0_0ck183 FIND v(dout0_0) AT=1840.05n

* CHECK dout0_1 Vdout0_1ck183 = 1.8 time = 1840
.meas tran vdout0_1ck183 FIND v(dout0_1) AT=1840.05n

* CHECK dout0_2 Vdout0_2ck183 = 1.8 time = 1840
.meas tran vdout0_2ck183 FIND v(dout0_2) AT=1840.05n

* CHECK dout0_3 Vdout0_3ck183 = 1.8 time = 1840
.meas tran vdout0_3ck183 FIND v(dout0_3) AT=1840.05n

* CHECK dout0_4 Vdout0_4ck183 = 1.8 time = 1840
.meas tran vdout0_4ck183 FIND v(dout0_4) AT=1840.05n

* CHECK dout0_5 Vdout0_5ck183 = 0 time = 1840
.meas tran vdout0_5ck183 FIND v(dout0_5) AT=1840.05n

* CHECK dout0_6 Vdout0_6ck183 = 1.8 time = 1840
.meas tran vdout0_6ck183 FIND v(dout0_6) AT=1840.05n

* CHECK dout0_7 Vdout0_7ck183 = 0 time = 1840
.meas tran vdout0_7ck183 FIND v(dout0_7) AT=1840.05n

* CHECK dout0_8 Vdout0_8ck183 = 1.8 time = 1840
.meas tran vdout0_8ck183 FIND v(dout0_8) AT=1840.05n

* CHECK dout0_9 Vdout0_9ck183 = 1.8 time = 1840
.meas tran vdout0_9ck183 FIND v(dout0_9) AT=1840.05n

* CHECK dout0_10 Vdout0_10ck183 = 0 time = 1840
.meas tran vdout0_10ck183 FIND v(dout0_10) AT=1840.05n

* CHECK dout0_11 Vdout0_11ck183 = 1.8 time = 1840
.meas tran vdout0_11ck183 FIND v(dout0_11) AT=1840.05n

* CHECK dout0_12 Vdout0_12ck183 = 1.8 time = 1840
.meas tran vdout0_12ck183 FIND v(dout0_12) AT=1840.05n

* CHECK dout0_13 Vdout0_13ck183 = 1.8 time = 1840
.meas tran vdout0_13ck183 FIND v(dout0_13) AT=1840.05n

* CHECK dout0_14 Vdout0_14ck183 = 0 time = 1840
.meas tran vdout0_14ck183 FIND v(dout0_14) AT=1840.05n

* CHECK dout0_15 Vdout0_15ck183 = 0 time = 1840
.meas tran vdout0_15ck183 FIND v(dout0_15) AT=1840.05n

* CHECK dout0_16 Vdout0_16ck183 = 1.8 time = 1840
.meas tran vdout0_16ck183 FIND v(dout0_16) AT=1840.05n

* CHECK dout0_17 Vdout0_17ck183 = 1.8 time = 1840
.meas tran vdout0_17ck183 FIND v(dout0_17) AT=1840.05n

* CHECK dout0_18 Vdout0_18ck183 = 1.8 time = 1840
.meas tran vdout0_18ck183 FIND v(dout0_18) AT=1840.05n

* CHECK dout0_19 Vdout0_19ck183 = 1.8 time = 1840
.meas tran vdout0_19ck183 FIND v(dout0_19) AT=1840.05n

* CHECK dout0_20 Vdout0_20ck183 = 1.8 time = 1840
.meas tran vdout0_20ck183 FIND v(dout0_20) AT=1840.05n

* CHECK dout0_21 Vdout0_21ck183 = 0 time = 1840
.meas tran vdout0_21ck183 FIND v(dout0_21) AT=1840.05n

* CHECK dout0_22 Vdout0_22ck183 = 1.8 time = 1840
.meas tran vdout0_22ck183 FIND v(dout0_22) AT=1840.05n

* CHECK dout0_23 Vdout0_23ck183 = 1.8 time = 1840
.meas tran vdout0_23ck183 FIND v(dout0_23) AT=1840.05n

* CHECK dout0_24 Vdout0_24ck183 = 1.8 time = 1840
.meas tran vdout0_24ck183 FIND v(dout0_24) AT=1840.05n

* CHECK dout0_25 Vdout0_25ck183 = 1.8 time = 1840
.meas tran vdout0_25ck183 FIND v(dout0_25) AT=1840.05n

* CHECK dout0_26 Vdout0_26ck183 = 1.8 time = 1840
.meas tran vdout0_26ck183 FIND v(dout0_26) AT=1840.05n

* CHECK dout0_27 Vdout0_27ck183 = 1.8 time = 1840
.meas tran vdout0_27ck183 FIND v(dout0_27) AT=1840.05n

* CHECK dout0_28 Vdout0_28ck183 = 0 time = 1840
.meas tran vdout0_28ck183 FIND v(dout0_28) AT=1840.05n

* CHECK dout0_29 Vdout0_29ck183 = 0 time = 1840
.meas tran vdout0_29ck183 FIND v(dout0_29) AT=1840.05n

* CHECK dout0_30 Vdout0_30ck183 = 0 time = 1840
.meas tran vdout0_30ck183 FIND v(dout0_30) AT=1840.05n

* CHECK dout0_31 Vdout0_31ck183 = 0 time = 1840
.meas tran vdout0_31ck183 FIND v(dout0_31) AT=1840.05n

* CHECK dout1_0 Vdout1_0ck183 = 0 time = 1840
.meas tran vdout1_0ck183 FIND v(dout1_0) AT=1840.05n

* CHECK dout1_1 Vdout1_1ck183 = 1.8 time = 1840
.meas tran vdout1_1ck183 FIND v(dout1_1) AT=1840.05n

* CHECK dout1_2 Vdout1_2ck183 = 0 time = 1840
.meas tran vdout1_2ck183 FIND v(dout1_2) AT=1840.05n

* CHECK dout1_3 Vdout1_3ck183 = 0 time = 1840
.meas tran vdout1_3ck183 FIND v(dout1_3) AT=1840.05n

* CHECK dout1_4 Vdout1_4ck183 = 0 time = 1840
.meas tran vdout1_4ck183 FIND v(dout1_4) AT=1840.05n

* CHECK dout1_5 Vdout1_5ck183 = 1.8 time = 1840
.meas tran vdout1_5ck183 FIND v(dout1_5) AT=1840.05n

* CHECK dout1_6 Vdout1_6ck183 = 0 time = 1840
.meas tran vdout1_6ck183 FIND v(dout1_6) AT=1840.05n

* CHECK dout1_7 Vdout1_7ck183 = 1.8 time = 1840
.meas tran vdout1_7ck183 FIND v(dout1_7) AT=1840.05n

* CHECK dout1_8 Vdout1_8ck183 = 1.8 time = 1840
.meas tran vdout1_8ck183 FIND v(dout1_8) AT=1840.05n

* CHECK dout1_9 Vdout1_9ck183 = 1.8 time = 1840
.meas tran vdout1_9ck183 FIND v(dout1_9) AT=1840.05n

* CHECK dout1_10 Vdout1_10ck183 = 0 time = 1840
.meas tran vdout1_10ck183 FIND v(dout1_10) AT=1840.05n

* CHECK dout1_11 Vdout1_11ck183 = 0 time = 1840
.meas tran vdout1_11ck183 FIND v(dout1_11) AT=1840.05n

* CHECK dout1_12 Vdout1_12ck183 = 0 time = 1840
.meas tran vdout1_12ck183 FIND v(dout1_12) AT=1840.05n

* CHECK dout1_13 Vdout1_13ck183 = 0 time = 1840
.meas tran vdout1_13ck183 FIND v(dout1_13) AT=1840.05n

* CHECK dout1_14 Vdout1_14ck183 = 0 time = 1840
.meas tran vdout1_14ck183 FIND v(dout1_14) AT=1840.05n

* CHECK dout1_15 Vdout1_15ck183 = 1.8 time = 1840
.meas tran vdout1_15ck183 FIND v(dout1_15) AT=1840.05n

* CHECK dout1_16 Vdout1_16ck183 = 0 time = 1840
.meas tran vdout1_16ck183 FIND v(dout1_16) AT=1840.05n

* CHECK dout1_17 Vdout1_17ck183 = 1.8 time = 1840
.meas tran vdout1_17ck183 FIND v(dout1_17) AT=1840.05n

* CHECK dout1_18 Vdout1_18ck183 = 1.8 time = 1840
.meas tran vdout1_18ck183 FIND v(dout1_18) AT=1840.05n

* CHECK dout1_19 Vdout1_19ck183 = 1.8 time = 1840
.meas tran vdout1_19ck183 FIND v(dout1_19) AT=1840.05n

* CHECK dout1_20 Vdout1_20ck183 = 0 time = 1840
.meas tran vdout1_20ck183 FIND v(dout1_20) AT=1840.05n

* CHECK dout1_21 Vdout1_21ck183 = 0 time = 1840
.meas tran vdout1_21ck183 FIND v(dout1_21) AT=1840.05n

* CHECK dout1_22 Vdout1_22ck183 = 0 time = 1840
.meas tran vdout1_22ck183 FIND v(dout1_22) AT=1840.05n

* CHECK dout1_23 Vdout1_23ck183 = 1.8 time = 1840
.meas tran vdout1_23ck183 FIND v(dout1_23) AT=1840.05n

* CHECK dout1_24 Vdout1_24ck183 = 0 time = 1840
.meas tran vdout1_24ck183 FIND v(dout1_24) AT=1840.05n

* CHECK dout1_25 Vdout1_25ck183 = 0 time = 1840
.meas tran vdout1_25ck183 FIND v(dout1_25) AT=1840.05n

* CHECK dout1_26 Vdout1_26ck183 = 1.8 time = 1840
.meas tran vdout1_26ck183 FIND v(dout1_26) AT=1840.05n

* CHECK dout1_27 Vdout1_27ck183 = 0 time = 1840
.meas tran vdout1_27ck183 FIND v(dout1_27) AT=1840.05n

* CHECK dout1_28 Vdout1_28ck183 = 0 time = 1840
.meas tran vdout1_28ck183 FIND v(dout1_28) AT=1840.05n

* CHECK dout1_29 Vdout1_29ck183 = 1.8 time = 1840
.meas tran vdout1_29ck183 FIND v(dout1_29) AT=1840.05n

* CHECK dout1_30 Vdout1_30ck183 = 0 time = 1840
.meas tran vdout1_30ck183 FIND v(dout1_30) AT=1840.05n

* CHECK dout1_31 Vdout1_31ck183 = 1.8 time = 1840
.meas tran vdout1_31ck183 FIND v(dout1_31) AT=1840.05n

* CHECK dout0_0 Vdout0_0ck184 = 0 time = 1850
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=1850.05n

* CHECK dout0_1 Vdout0_1ck184 = 1.8 time = 1850
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=1850.05n

* CHECK dout0_2 Vdout0_2ck184 = 1.8 time = 1850
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=1850.05n

* CHECK dout0_3 Vdout0_3ck184 = 1.8 time = 1850
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=1850.05n

* CHECK dout0_4 Vdout0_4ck184 = 1.8 time = 1850
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=1850.05n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 1850
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=1850.05n

* CHECK dout0_6 Vdout0_6ck184 = 1.8 time = 1850
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=1850.05n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 1850
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=1850.05n

* CHECK dout0_8 Vdout0_8ck184 = 1.8 time = 1850
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=1850.05n

* CHECK dout0_9 Vdout0_9ck184 = 1.8 time = 1850
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=1850.05n

* CHECK dout0_10 Vdout0_10ck184 = 0 time = 1850
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=1850.05n

* CHECK dout0_11 Vdout0_11ck184 = 1.8 time = 1850
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=1850.05n

* CHECK dout0_12 Vdout0_12ck184 = 1.8 time = 1850
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=1850.05n

* CHECK dout0_13 Vdout0_13ck184 = 1.8 time = 1850
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=1850.05n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 1850
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=1850.05n

* CHECK dout0_15 Vdout0_15ck184 = 0 time = 1850
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=1850.05n

* CHECK dout0_16 Vdout0_16ck184 = 1.8 time = 1850
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=1850.05n

* CHECK dout0_17 Vdout0_17ck184 = 1.8 time = 1850
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=1850.05n

* CHECK dout0_18 Vdout0_18ck184 = 1.8 time = 1850
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=1850.05n

* CHECK dout0_19 Vdout0_19ck184 = 1.8 time = 1850
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=1850.05n

* CHECK dout0_20 Vdout0_20ck184 = 1.8 time = 1850
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=1850.05n

* CHECK dout0_21 Vdout0_21ck184 = 0 time = 1850
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=1850.05n

* CHECK dout0_22 Vdout0_22ck184 = 1.8 time = 1850
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=1850.05n

* CHECK dout0_23 Vdout0_23ck184 = 1.8 time = 1850
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=1850.05n

* CHECK dout0_24 Vdout0_24ck184 = 1.8 time = 1850
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=1850.05n

* CHECK dout0_25 Vdout0_25ck184 = 1.8 time = 1850
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=1850.05n

* CHECK dout0_26 Vdout0_26ck184 = 1.8 time = 1850
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=1850.05n

* CHECK dout0_27 Vdout0_27ck184 = 1.8 time = 1850
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=1850.05n

* CHECK dout0_28 Vdout0_28ck184 = 0 time = 1850
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=1850.05n

* CHECK dout0_29 Vdout0_29ck184 = 0 time = 1850
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=1850.05n

* CHECK dout0_30 Vdout0_30ck184 = 0 time = 1850
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=1850.05n

* CHECK dout0_31 Vdout0_31ck184 = 0 time = 1850
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=1850.05n

* CHECK dout1_0 Vdout1_0ck184 = 0 time = 1850
.meas tran vdout1_0ck184 FIND v(dout1_0) AT=1850.05n

* CHECK dout1_1 Vdout1_1ck184 = 1.8 time = 1850
.meas tran vdout1_1ck184 FIND v(dout1_1) AT=1850.05n

* CHECK dout1_2 Vdout1_2ck184 = 1.8 time = 1850
.meas tran vdout1_2ck184 FIND v(dout1_2) AT=1850.05n

* CHECK dout1_3 Vdout1_3ck184 = 1.8 time = 1850
.meas tran vdout1_3ck184 FIND v(dout1_3) AT=1850.05n

* CHECK dout1_4 Vdout1_4ck184 = 1.8 time = 1850
.meas tran vdout1_4ck184 FIND v(dout1_4) AT=1850.05n

* CHECK dout1_5 Vdout1_5ck184 = 0 time = 1850
.meas tran vdout1_5ck184 FIND v(dout1_5) AT=1850.05n

* CHECK dout1_6 Vdout1_6ck184 = 1.8 time = 1850
.meas tran vdout1_6ck184 FIND v(dout1_6) AT=1850.05n

* CHECK dout1_7 Vdout1_7ck184 = 0 time = 1850
.meas tran vdout1_7ck184 FIND v(dout1_7) AT=1850.05n

* CHECK dout1_8 Vdout1_8ck184 = 1.8 time = 1850
.meas tran vdout1_8ck184 FIND v(dout1_8) AT=1850.05n

* CHECK dout1_9 Vdout1_9ck184 = 1.8 time = 1850
.meas tran vdout1_9ck184 FIND v(dout1_9) AT=1850.05n

* CHECK dout1_10 Vdout1_10ck184 = 0 time = 1850
.meas tran vdout1_10ck184 FIND v(dout1_10) AT=1850.05n

* CHECK dout1_11 Vdout1_11ck184 = 1.8 time = 1850
.meas tran vdout1_11ck184 FIND v(dout1_11) AT=1850.05n

* CHECK dout1_12 Vdout1_12ck184 = 1.8 time = 1850
.meas tran vdout1_12ck184 FIND v(dout1_12) AT=1850.05n

* CHECK dout1_13 Vdout1_13ck184 = 1.8 time = 1850
.meas tran vdout1_13ck184 FIND v(dout1_13) AT=1850.05n

* CHECK dout1_14 Vdout1_14ck184 = 0 time = 1850
.meas tran vdout1_14ck184 FIND v(dout1_14) AT=1850.05n

* CHECK dout1_15 Vdout1_15ck184 = 0 time = 1850
.meas tran vdout1_15ck184 FIND v(dout1_15) AT=1850.05n

* CHECK dout1_16 Vdout1_16ck184 = 1.8 time = 1850
.meas tran vdout1_16ck184 FIND v(dout1_16) AT=1850.05n

* CHECK dout1_17 Vdout1_17ck184 = 1.8 time = 1850
.meas tran vdout1_17ck184 FIND v(dout1_17) AT=1850.05n

* CHECK dout1_18 Vdout1_18ck184 = 1.8 time = 1850
.meas tran vdout1_18ck184 FIND v(dout1_18) AT=1850.05n

* CHECK dout1_19 Vdout1_19ck184 = 1.8 time = 1850
.meas tran vdout1_19ck184 FIND v(dout1_19) AT=1850.05n

* CHECK dout1_20 Vdout1_20ck184 = 1.8 time = 1850
.meas tran vdout1_20ck184 FIND v(dout1_20) AT=1850.05n

* CHECK dout1_21 Vdout1_21ck184 = 0 time = 1850
.meas tran vdout1_21ck184 FIND v(dout1_21) AT=1850.05n

* CHECK dout1_22 Vdout1_22ck184 = 1.8 time = 1850
.meas tran vdout1_22ck184 FIND v(dout1_22) AT=1850.05n

* CHECK dout1_23 Vdout1_23ck184 = 1.8 time = 1850
.meas tran vdout1_23ck184 FIND v(dout1_23) AT=1850.05n

* CHECK dout1_24 Vdout1_24ck184 = 1.8 time = 1850
.meas tran vdout1_24ck184 FIND v(dout1_24) AT=1850.05n

* CHECK dout1_25 Vdout1_25ck184 = 1.8 time = 1850
.meas tran vdout1_25ck184 FIND v(dout1_25) AT=1850.05n

* CHECK dout1_26 Vdout1_26ck184 = 1.8 time = 1850
.meas tran vdout1_26ck184 FIND v(dout1_26) AT=1850.05n

* CHECK dout1_27 Vdout1_27ck184 = 1.8 time = 1850
.meas tran vdout1_27ck184 FIND v(dout1_27) AT=1850.05n

* CHECK dout1_28 Vdout1_28ck184 = 0 time = 1850
.meas tran vdout1_28ck184 FIND v(dout1_28) AT=1850.05n

* CHECK dout1_29 Vdout1_29ck184 = 0 time = 1850
.meas tran vdout1_29ck184 FIND v(dout1_29) AT=1850.05n

* CHECK dout1_30 Vdout1_30ck184 = 0 time = 1850
.meas tran vdout1_30ck184 FIND v(dout1_30) AT=1850.05n

* CHECK dout1_31 Vdout1_31ck184 = 0 time = 1850
.meas tran vdout1_31ck184 FIND v(dout1_31) AT=1850.05n

* CHECK dout1_0 Vdout1_0ck185 = 0 time = 1860
.meas tran vdout1_0ck185 FIND v(dout1_0) AT=1860.05n

* CHECK dout1_1 Vdout1_1ck185 = 1.8 time = 1860
.meas tran vdout1_1ck185 FIND v(dout1_1) AT=1860.05n

* CHECK dout1_2 Vdout1_2ck185 = 0 time = 1860
.meas tran vdout1_2ck185 FIND v(dout1_2) AT=1860.05n

* CHECK dout1_3 Vdout1_3ck185 = 0 time = 1860
.meas tran vdout1_3ck185 FIND v(dout1_3) AT=1860.05n

* CHECK dout1_4 Vdout1_4ck185 = 0 time = 1860
.meas tran vdout1_4ck185 FIND v(dout1_4) AT=1860.05n

* CHECK dout1_5 Vdout1_5ck185 = 1.8 time = 1860
.meas tran vdout1_5ck185 FIND v(dout1_5) AT=1860.05n

* CHECK dout1_6 Vdout1_6ck185 = 0 time = 1860
.meas tran vdout1_6ck185 FIND v(dout1_6) AT=1860.05n

* CHECK dout1_7 Vdout1_7ck185 = 1.8 time = 1860
.meas tran vdout1_7ck185 FIND v(dout1_7) AT=1860.05n

* CHECK dout1_8 Vdout1_8ck185 = 1.8 time = 1860
.meas tran vdout1_8ck185 FIND v(dout1_8) AT=1860.05n

* CHECK dout1_9 Vdout1_9ck185 = 1.8 time = 1860
.meas tran vdout1_9ck185 FIND v(dout1_9) AT=1860.05n

* CHECK dout1_10 Vdout1_10ck185 = 0 time = 1860
.meas tran vdout1_10ck185 FIND v(dout1_10) AT=1860.05n

* CHECK dout1_11 Vdout1_11ck185 = 0 time = 1860
.meas tran vdout1_11ck185 FIND v(dout1_11) AT=1860.05n

* CHECK dout1_12 Vdout1_12ck185 = 0 time = 1860
.meas tran vdout1_12ck185 FIND v(dout1_12) AT=1860.05n

* CHECK dout1_13 Vdout1_13ck185 = 0 time = 1860
.meas tran vdout1_13ck185 FIND v(dout1_13) AT=1860.05n

* CHECK dout1_14 Vdout1_14ck185 = 0 time = 1860
.meas tran vdout1_14ck185 FIND v(dout1_14) AT=1860.05n

* CHECK dout1_15 Vdout1_15ck185 = 1.8 time = 1860
.meas tran vdout1_15ck185 FIND v(dout1_15) AT=1860.05n

* CHECK dout1_16 Vdout1_16ck185 = 0 time = 1860
.meas tran vdout1_16ck185 FIND v(dout1_16) AT=1860.05n

* CHECK dout1_17 Vdout1_17ck185 = 1.8 time = 1860
.meas tran vdout1_17ck185 FIND v(dout1_17) AT=1860.05n

* CHECK dout1_18 Vdout1_18ck185 = 1.8 time = 1860
.meas tran vdout1_18ck185 FIND v(dout1_18) AT=1860.05n

* CHECK dout1_19 Vdout1_19ck185 = 1.8 time = 1860
.meas tran vdout1_19ck185 FIND v(dout1_19) AT=1860.05n

* CHECK dout1_20 Vdout1_20ck185 = 0 time = 1860
.meas tran vdout1_20ck185 FIND v(dout1_20) AT=1860.05n

* CHECK dout1_21 Vdout1_21ck185 = 0 time = 1860
.meas tran vdout1_21ck185 FIND v(dout1_21) AT=1860.05n

* CHECK dout1_22 Vdout1_22ck185 = 0 time = 1860
.meas tran vdout1_22ck185 FIND v(dout1_22) AT=1860.05n

* CHECK dout1_23 Vdout1_23ck185 = 1.8 time = 1860
.meas tran vdout1_23ck185 FIND v(dout1_23) AT=1860.05n

* CHECK dout1_24 Vdout1_24ck185 = 0 time = 1860
.meas tran vdout1_24ck185 FIND v(dout1_24) AT=1860.05n

* CHECK dout1_25 Vdout1_25ck185 = 0 time = 1860
.meas tran vdout1_25ck185 FIND v(dout1_25) AT=1860.05n

* CHECK dout1_26 Vdout1_26ck185 = 1.8 time = 1860
.meas tran vdout1_26ck185 FIND v(dout1_26) AT=1860.05n

* CHECK dout1_27 Vdout1_27ck185 = 0 time = 1860
.meas tran vdout1_27ck185 FIND v(dout1_27) AT=1860.05n

* CHECK dout1_28 Vdout1_28ck185 = 0 time = 1860
.meas tran vdout1_28ck185 FIND v(dout1_28) AT=1860.05n

* CHECK dout1_29 Vdout1_29ck185 = 1.8 time = 1860
.meas tran vdout1_29ck185 FIND v(dout1_29) AT=1860.05n

* CHECK dout1_30 Vdout1_30ck185 = 0 time = 1860
.meas tran vdout1_30ck185 FIND v(dout1_30) AT=1860.05n

* CHECK dout1_31 Vdout1_31ck185 = 1.8 time = 1860
.meas tran vdout1_31ck185 FIND v(dout1_31) AT=1860.05n

* CHECK dout0_0 Vdout0_0ck186 = 0 time = 1870
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=1870.05n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 1870
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=1870.05n

* CHECK dout0_2 Vdout0_2ck186 = 1.8 time = 1870
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=1870.05n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 1870
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=1870.05n

* CHECK dout0_4 Vdout0_4ck186 = 1.8 time = 1870
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=1870.05n

* CHECK dout0_5 Vdout0_5ck186 = 0 time = 1870
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=1870.05n

* CHECK dout0_6 Vdout0_6ck186 = 1.8 time = 1870
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=1870.05n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 1870
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=1870.05n

* CHECK dout0_8 Vdout0_8ck186 = 1.8 time = 1870
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=1870.05n

* CHECK dout0_9 Vdout0_9ck186 = 1.8 time = 1870
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=1870.05n

* CHECK dout0_10 Vdout0_10ck186 = 0 time = 1870
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=1870.05n

* CHECK dout0_11 Vdout0_11ck186 = 1.8 time = 1870
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=1870.05n

* CHECK dout0_12 Vdout0_12ck186 = 1.8 time = 1870
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=1870.05n

* CHECK dout0_13 Vdout0_13ck186 = 1.8 time = 1870
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=1870.05n

* CHECK dout0_14 Vdout0_14ck186 = 0 time = 1870
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=1870.05n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 1870
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=1870.05n

* CHECK dout0_16 Vdout0_16ck186 = 1.8 time = 1870
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=1870.05n

* CHECK dout0_17 Vdout0_17ck186 = 1.8 time = 1870
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=1870.05n

* CHECK dout0_18 Vdout0_18ck186 = 1.8 time = 1870
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=1870.05n

* CHECK dout0_19 Vdout0_19ck186 = 1.8 time = 1870
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=1870.05n

* CHECK dout0_20 Vdout0_20ck186 = 1.8 time = 1870
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=1870.05n

* CHECK dout0_21 Vdout0_21ck186 = 0 time = 1870
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=1870.05n

* CHECK dout0_22 Vdout0_22ck186 = 1.8 time = 1870
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=1870.05n

* CHECK dout0_23 Vdout0_23ck186 = 1.8 time = 1870
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=1870.05n

* CHECK dout0_24 Vdout0_24ck186 = 1.8 time = 1870
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=1870.05n

* CHECK dout0_25 Vdout0_25ck186 = 1.8 time = 1870
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=1870.05n

* CHECK dout0_26 Vdout0_26ck186 = 1.8 time = 1870
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=1870.05n

* CHECK dout0_27 Vdout0_27ck186 = 1.8 time = 1870
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=1870.05n

* CHECK dout0_28 Vdout0_28ck186 = 0 time = 1870
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=1870.05n

* CHECK dout0_29 Vdout0_29ck186 = 0 time = 1870
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=1870.05n

* CHECK dout0_30 Vdout0_30ck186 = 0 time = 1870
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=1870.05n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 1870
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=1870.05n

* CHECK dout0_0 Vdout0_0ck188 = 0 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 1.8 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 1.8 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 1.8 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 1.8 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 1.8 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_8 Vdout0_8ck188 = 1.8 time = 1890
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=1890.05n

* CHECK dout0_9 Vdout0_9ck188 = 1.8 time = 1890
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=1890.05n

* CHECK dout0_10 Vdout0_10ck188 = 0 time = 1890
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=1890.05n

* CHECK dout0_11 Vdout0_11ck188 = 1.8 time = 1890
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=1890.05n

* CHECK dout0_12 Vdout0_12ck188 = 1.8 time = 1890
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=1890.05n

* CHECK dout0_13 Vdout0_13ck188 = 1.8 time = 1890
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=1890.05n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 1890
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=1890.05n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 1890
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=1890.05n

* CHECK dout0_16 Vdout0_16ck188 = 0 time = 1890
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=1890.05n

* CHECK dout0_17 Vdout0_17ck188 = 0 time = 1890
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=1890.05n

* CHECK dout0_18 Vdout0_18ck188 = 1.8 time = 1890
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=1890.05n

* CHECK dout0_19 Vdout0_19ck188 = 0 time = 1890
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=1890.05n

* CHECK dout0_20 Vdout0_20ck188 = 1.8 time = 1890
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=1890.05n

* CHECK dout0_21 Vdout0_21ck188 = 1.8 time = 1890
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=1890.05n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 1890
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=1890.05n

* CHECK dout0_23 Vdout0_23ck188 = 1.8 time = 1890
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=1890.05n

* CHECK dout0_24 Vdout0_24ck188 = 1.8 time = 1890
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=1890.05n

* CHECK dout0_25 Vdout0_25ck188 = 1.8 time = 1890
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=1890.05n

* CHECK dout0_26 Vdout0_26ck188 = 1.8 time = 1890
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=1890.05n

* CHECK dout0_27 Vdout0_27ck188 = 1.8 time = 1890
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=1890.05n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 1890
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=1890.05n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 1890
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=1890.05n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 1890
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=1890.05n

* CHECK dout0_31 Vdout0_31ck188 = 0 time = 1890
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck189 = 0 time = 1900
.meas tran vdout0_0ck189 FIND v(dout0_0) AT=1900.05n

* CHECK dout0_1 Vdout0_1ck189 = 0 time = 1900
.meas tran vdout0_1ck189 FIND v(dout0_1) AT=1900.05n

* CHECK dout0_2 Vdout0_2ck189 = 0 time = 1900
.meas tran vdout0_2ck189 FIND v(dout0_2) AT=1900.05n

* CHECK dout0_3 Vdout0_3ck189 = 0 time = 1900
.meas tran vdout0_3ck189 FIND v(dout0_3) AT=1900.05n

* CHECK dout0_4 Vdout0_4ck189 = 1.8 time = 1900
.meas tran vdout0_4ck189 FIND v(dout0_4) AT=1900.05n

* CHECK dout0_5 Vdout0_5ck189 = 0 time = 1900
.meas tran vdout0_5ck189 FIND v(dout0_5) AT=1900.05n

* CHECK dout0_6 Vdout0_6ck189 = 0 time = 1900
.meas tran vdout0_6ck189 FIND v(dout0_6) AT=1900.05n

* CHECK dout0_7 Vdout0_7ck189 = 0 time = 1900
.meas tran vdout0_7ck189 FIND v(dout0_7) AT=1900.05n

* CHECK dout0_8 Vdout0_8ck189 = 0 time = 1900
.meas tran vdout0_8ck189 FIND v(dout0_8) AT=1900.05n

* CHECK dout0_9 Vdout0_9ck189 = 1.8 time = 1900
.meas tran vdout0_9ck189 FIND v(dout0_9) AT=1900.05n

* CHECK dout0_10 Vdout0_10ck189 = 1.8 time = 1900
.meas tran vdout0_10ck189 FIND v(dout0_10) AT=1900.05n

* CHECK dout0_11 Vdout0_11ck189 = 0 time = 1900
.meas tran vdout0_11ck189 FIND v(dout0_11) AT=1900.05n

* CHECK dout0_12 Vdout0_12ck189 = 0 time = 1900
.meas tran vdout0_12ck189 FIND v(dout0_12) AT=1900.05n

* CHECK dout0_13 Vdout0_13ck189 = 1.8 time = 1900
.meas tran vdout0_13ck189 FIND v(dout0_13) AT=1900.05n

* CHECK dout0_14 Vdout0_14ck189 = 0 time = 1900
.meas tran vdout0_14ck189 FIND v(dout0_14) AT=1900.05n

* CHECK dout0_15 Vdout0_15ck189 = 0 time = 1900
.meas tran vdout0_15ck189 FIND v(dout0_15) AT=1900.05n

* CHECK dout0_16 Vdout0_16ck189 = 1.8 time = 1900
.meas tran vdout0_16ck189 FIND v(dout0_16) AT=1900.05n

* CHECK dout0_17 Vdout0_17ck189 = 0 time = 1900
.meas tran vdout0_17ck189 FIND v(dout0_17) AT=1900.05n

* CHECK dout0_18 Vdout0_18ck189 = 1.8 time = 1900
.meas tran vdout0_18ck189 FIND v(dout0_18) AT=1900.05n

* CHECK dout0_19 Vdout0_19ck189 = 0 time = 1900
.meas tran vdout0_19ck189 FIND v(dout0_19) AT=1900.05n

* CHECK dout0_20 Vdout0_20ck189 = 0 time = 1900
.meas tran vdout0_20ck189 FIND v(dout0_20) AT=1900.05n

* CHECK dout0_21 Vdout0_21ck189 = 1.8 time = 1900
.meas tran vdout0_21ck189 FIND v(dout0_21) AT=1900.05n

* CHECK dout0_22 Vdout0_22ck189 = 0 time = 1900
.meas tran vdout0_22ck189 FIND v(dout0_22) AT=1900.05n

* CHECK dout0_23 Vdout0_23ck189 = 0 time = 1900
.meas tran vdout0_23ck189 FIND v(dout0_23) AT=1900.05n

* CHECK dout0_24 Vdout0_24ck189 = 1.8 time = 1900
.meas tran vdout0_24ck189 FIND v(dout0_24) AT=1900.05n

* CHECK dout0_25 Vdout0_25ck189 = 1.8 time = 1900
.meas tran vdout0_25ck189 FIND v(dout0_25) AT=1900.05n

* CHECK dout0_26 Vdout0_26ck189 = 1.8 time = 1900
.meas tran vdout0_26ck189 FIND v(dout0_26) AT=1900.05n

* CHECK dout0_27 Vdout0_27ck189 = 0 time = 1900
.meas tran vdout0_27ck189 FIND v(dout0_27) AT=1900.05n

* CHECK dout0_28 Vdout0_28ck189 = 0 time = 1900
.meas tran vdout0_28ck189 FIND v(dout0_28) AT=1900.05n

* CHECK dout0_29 Vdout0_29ck189 = 0 time = 1900
.meas tran vdout0_29ck189 FIND v(dout0_29) AT=1900.05n

* CHECK dout0_30 Vdout0_30ck189 = 0 time = 1900
.meas tran vdout0_30ck189 FIND v(dout0_30) AT=1900.05n

* CHECK dout0_31 Vdout0_31ck189 = 1.8 time = 1900
.meas tran vdout0_31ck189 FIND v(dout0_31) AT=1900.05n

* CHECK dout1_0 Vdout1_0ck189 = 0 time = 1900
.meas tran vdout1_0ck189 FIND v(dout1_0) AT=1900.05n

* CHECK dout1_1 Vdout1_1ck189 = 0 time = 1900
.meas tran vdout1_1ck189 FIND v(dout1_1) AT=1900.05n

* CHECK dout1_2 Vdout1_2ck189 = 1.8 time = 1900
.meas tran vdout1_2ck189 FIND v(dout1_2) AT=1900.05n

* CHECK dout1_3 Vdout1_3ck189 = 0 time = 1900
.meas tran vdout1_3ck189 FIND v(dout1_3) AT=1900.05n

* CHECK dout1_4 Vdout1_4ck189 = 0 time = 1900
.meas tran vdout1_4ck189 FIND v(dout1_4) AT=1900.05n

* CHECK dout1_5 Vdout1_5ck189 = 1.8 time = 1900
.meas tran vdout1_5ck189 FIND v(dout1_5) AT=1900.05n

* CHECK dout1_6 Vdout1_6ck189 = 1.8 time = 1900
.meas tran vdout1_6ck189 FIND v(dout1_6) AT=1900.05n

* CHECK dout1_7 Vdout1_7ck189 = 0 time = 1900
.meas tran vdout1_7ck189 FIND v(dout1_7) AT=1900.05n

* CHECK dout1_8 Vdout1_8ck189 = 0 time = 1900
.meas tran vdout1_8ck189 FIND v(dout1_8) AT=1900.05n

* CHECK dout1_9 Vdout1_9ck189 = 1.8 time = 1900
.meas tran vdout1_9ck189 FIND v(dout1_9) AT=1900.05n

* CHECK dout1_10 Vdout1_10ck189 = 0 time = 1900
.meas tran vdout1_10ck189 FIND v(dout1_10) AT=1900.05n

* CHECK dout1_11 Vdout1_11ck189 = 0 time = 1900
.meas tran vdout1_11ck189 FIND v(dout1_11) AT=1900.05n

* CHECK dout1_12 Vdout1_12ck189 = 0 time = 1900
.meas tran vdout1_12ck189 FIND v(dout1_12) AT=1900.05n

* CHECK dout1_13 Vdout1_13ck189 = 1.8 time = 1900
.meas tran vdout1_13ck189 FIND v(dout1_13) AT=1900.05n

* CHECK dout1_14 Vdout1_14ck189 = 1.8 time = 1900
.meas tran vdout1_14ck189 FIND v(dout1_14) AT=1900.05n

* CHECK dout1_15 Vdout1_15ck189 = 0 time = 1900
.meas tran vdout1_15ck189 FIND v(dout1_15) AT=1900.05n

* CHECK dout1_16 Vdout1_16ck189 = 1.8 time = 1900
.meas tran vdout1_16ck189 FIND v(dout1_16) AT=1900.05n

* CHECK dout1_17 Vdout1_17ck189 = 1.8 time = 1900
.meas tran vdout1_17ck189 FIND v(dout1_17) AT=1900.05n

* CHECK dout1_18 Vdout1_18ck189 = 0 time = 1900
.meas tran vdout1_18ck189 FIND v(dout1_18) AT=1900.05n

* CHECK dout1_19 Vdout1_19ck189 = 0 time = 1900
.meas tran vdout1_19ck189 FIND v(dout1_19) AT=1900.05n

* CHECK dout1_20 Vdout1_20ck189 = 0 time = 1900
.meas tran vdout1_20ck189 FIND v(dout1_20) AT=1900.05n

* CHECK dout1_21 Vdout1_21ck189 = 1.8 time = 1900
.meas tran vdout1_21ck189 FIND v(dout1_21) AT=1900.05n

* CHECK dout1_22 Vdout1_22ck189 = 1.8 time = 1900
.meas tran vdout1_22ck189 FIND v(dout1_22) AT=1900.05n

* CHECK dout1_23 Vdout1_23ck189 = 0 time = 1900
.meas tran vdout1_23ck189 FIND v(dout1_23) AT=1900.05n

* CHECK dout1_24 Vdout1_24ck189 = 1.8 time = 1900
.meas tran vdout1_24ck189 FIND v(dout1_24) AT=1900.05n

* CHECK dout1_25 Vdout1_25ck189 = 0 time = 1900
.meas tran vdout1_25ck189 FIND v(dout1_25) AT=1900.05n

* CHECK dout1_26 Vdout1_26ck189 = 1.8 time = 1900
.meas tran vdout1_26ck189 FIND v(dout1_26) AT=1900.05n

* CHECK dout1_27 Vdout1_27ck189 = 0 time = 1900
.meas tran vdout1_27ck189 FIND v(dout1_27) AT=1900.05n

* CHECK dout1_28 Vdout1_28ck189 = 0 time = 1900
.meas tran vdout1_28ck189 FIND v(dout1_28) AT=1900.05n

* CHECK dout1_29 Vdout1_29ck189 = 1.8 time = 1900
.meas tran vdout1_29ck189 FIND v(dout1_29) AT=1900.05n

* CHECK dout1_30 Vdout1_30ck189 = 1.8 time = 1900
.meas tran vdout1_30ck189 FIND v(dout1_30) AT=1900.05n

* CHECK dout1_31 Vdout1_31ck189 = 1.8 time = 1900
.meas tran vdout1_31ck189 FIND v(dout1_31) AT=1900.05n

* CHECK dout1_0 Vdout1_0ck190 = 0 time = 1910
.meas tran vdout1_0ck190 FIND v(dout1_0) AT=1910.05n

* CHECK dout1_1 Vdout1_1ck190 = 1.8 time = 1910
.meas tran vdout1_1ck190 FIND v(dout1_1) AT=1910.05n

* CHECK dout1_2 Vdout1_2ck190 = 0 time = 1910
.meas tran vdout1_2ck190 FIND v(dout1_2) AT=1910.05n

* CHECK dout1_3 Vdout1_3ck190 = 0 time = 1910
.meas tran vdout1_3ck190 FIND v(dout1_3) AT=1910.05n

* CHECK dout1_4 Vdout1_4ck190 = 0 time = 1910
.meas tran vdout1_4ck190 FIND v(dout1_4) AT=1910.05n

* CHECK dout1_5 Vdout1_5ck190 = 1.8 time = 1910
.meas tran vdout1_5ck190 FIND v(dout1_5) AT=1910.05n

* CHECK dout1_6 Vdout1_6ck190 = 0 time = 1910
.meas tran vdout1_6ck190 FIND v(dout1_6) AT=1910.05n

* CHECK dout1_7 Vdout1_7ck190 = 1.8 time = 1910
.meas tran vdout1_7ck190 FIND v(dout1_7) AT=1910.05n

* CHECK dout1_8 Vdout1_8ck190 = 1.8 time = 1910
.meas tran vdout1_8ck190 FIND v(dout1_8) AT=1910.05n

* CHECK dout1_9 Vdout1_9ck190 = 1.8 time = 1910
.meas tran vdout1_9ck190 FIND v(dout1_9) AT=1910.05n

* CHECK dout1_10 Vdout1_10ck190 = 0 time = 1910
.meas tran vdout1_10ck190 FIND v(dout1_10) AT=1910.05n

* CHECK dout1_11 Vdout1_11ck190 = 0 time = 1910
.meas tran vdout1_11ck190 FIND v(dout1_11) AT=1910.05n

* CHECK dout1_12 Vdout1_12ck190 = 0 time = 1910
.meas tran vdout1_12ck190 FIND v(dout1_12) AT=1910.05n

* CHECK dout1_13 Vdout1_13ck190 = 0 time = 1910
.meas tran vdout1_13ck190 FIND v(dout1_13) AT=1910.05n

* CHECK dout1_14 Vdout1_14ck190 = 0 time = 1910
.meas tran vdout1_14ck190 FIND v(dout1_14) AT=1910.05n

* CHECK dout1_15 Vdout1_15ck190 = 1.8 time = 1910
.meas tran vdout1_15ck190 FIND v(dout1_15) AT=1910.05n

* CHECK dout1_16 Vdout1_16ck190 = 0 time = 1910
.meas tran vdout1_16ck190 FIND v(dout1_16) AT=1910.05n

* CHECK dout1_17 Vdout1_17ck190 = 1.8 time = 1910
.meas tran vdout1_17ck190 FIND v(dout1_17) AT=1910.05n

* CHECK dout1_18 Vdout1_18ck190 = 1.8 time = 1910
.meas tran vdout1_18ck190 FIND v(dout1_18) AT=1910.05n

* CHECK dout1_19 Vdout1_19ck190 = 1.8 time = 1910
.meas tran vdout1_19ck190 FIND v(dout1_19) AT=1910.05n

* CHECK dout1_20 Vdout1_20ck190 = 0 time = 1910
.meas tran vdout1_20ck190 FIND v(dout1_20) AT=1910.05n

* CHECK dout1_21 Vdout1_21ck190 = 0 time = 1910
.meas tran vdout1_21ck190 FIND v(dout1_21) AT=1910.05n

* CHECK dout1_22 Vdout1_22ck190 = 0 time = 1910
.meas tran vdout1_22ck190 FIND v(dout1_22) AT=1910.05n

* CHECK dout1_23 Vdout1_23ck190 = 1.8 time = 1910
.meas tran vdout1_23ck190 FIND v(dout1_23) AT=1910.05n

* CHECK dout1_24 Vdout1_24ck190 = 0 time = 1910
.meas tran vdout1_24ck190 FIND v(dout1_24) AT=1910.05n

* CHECK dout1_25 Vdout1_25ck190 = 0 time = 1910
.meas tran vdout1_25ck190 FIND v(dout1_25) AT=1910.05n

* CHECK dout1_26 Vdout1_26ck190 = 1.8 time = 1910
.meas tran vdout1_26ck190 FIND v(dout1_26) AT=1910.05n

* CHECK dout1_27 Vdout1_27ck190 = 0 time = 1910
.meas tran vdout1_27ck190 FIND v(dout1_27) AT=1910.05n

* CHECK dout1_28 Vdout1_28ck190 = 0 time = 1910
.meas tran vdout1_28ck190 FIND v(dout1_28) AT=1910.05n

* CHECK dout1_29 Vdout1_29ck190 = 1.8 time = 1910
.meas tran vdout1_29ck190 FIND v(dout1_29) AT=1910.05n

* CHECK dout1_30 Vdout1_30ck190 = 0 time = 1910
.meas tran vdout1_30ck190 FIND v(dout1_30) AT=1910.05n

* CHECK dout1_31 Vdout1_31ck190 = 1.8 time = 1910
.meas tran vdout1_31ck190 FIND v(dout1_31) AT=1910.05n

* CHECK dout1_0 Vdout1_0ck191 = 0 time = 1920
.meas tran vdout1_0ck191 FIND v(dout1_0) AT=1920.05n

* CHECK dout1_1 Vdout1_1ck191 = 1.8 time = 1920
.meas tran vdout1_1ck191 FIND v(dout1_1) AT=1920.05n

* CHECK dout1_2 Vdout1_2ck191 = 0 time = 1920
.meas tran vdout1_2ck191 FIND v(dout1_2) AT=1920.05n

* CHECK dout1_3 Vdout1_3ck191 = 0 time = 1920
.meas tran vdout1_3ck191 FIND v(dout1_3) AT=1920.05n

* CHECK dout1_4 Vdout1_4ck191 = 0 time = 1920
.meas tran vdout1_4ck191 FIND v(dout1_4) AT=1920.05n

* CHECK dout1_5 Vdout1_5ck191 = 1.8 time = 1920
.meas tran vdout1_5ck191 FIND v(dout1_5) AT=1920.05n

* CHECK dout1_6 Vdout1_6ck191 = 0 time = 1920
.meas tran vdout1_6ck191 FIND v(dout1_6) AT=1920.05n

* CHECK dout1_7 Vdout1_7ck191 = 1.8 time = 1920
.meas tran vdout1_7ck191 FIND v(dout1_7) AT=1920.05n

* CHECK dout1_8 Vdout1_8ck191 = 1.8 time = 1920
.meas tran vdout1_8ck191 FIND v(dout1_8) AT=1920.05n

* CHECK dout1_9 Vdout1_9ck191 = 1.8 time = 1920
.meas tran vdout1_9ck191 FIND v(dout1_9) AT=1920.05n

* CHECK dout1_10 Vdout1_10ck191 = 0 time = 1920
.meas tran vdout1_10ck191 FIND v(dout1_10) AT=1920.05n

* CHECK dout1_11 Vdout1_11ck191 = 0 time = 1920
.meas tran vdout1_11ck191 FIND v(dout1_11) AT=1920.05n

* CHECK dout1_12 Vdout1_12ck191 = 0 time = 1920
.meas tran vdout1_12ck191 FIND v(dout1_12) AT=1920.05n

* CHECK dout1_13 Vdout1_13ck191 = 0 time = 1920
.meas tran vdout1_13ck191 FIND v(dout1_13) AT=1920.05n

* CHECK dout1_14 Vdout1_14ck191 = 0 time = 1920
.meas tran vdout1_14ck191 FIND v(dout1_14) AT=1920.05n

* CHECK dout1_15 Vdout1_15ck191 = 1.8 time = 1920
.meas tran vdout1_15ck191 FIND v(dout1_15) AT=1920.05n

* CHECK dout1_16 Vdout1_16ck191 = 0 time = 1920
.meas tran vdout1_16ck191 FIND v(dout1_16) AT=1920.05n

* CHECK dout1_17 Vdout1_17ck191 = 1.8 time = 1920
.meas tran vdout1_17ck191 FIND v(dout1_17) AT=1920.05n

* CHECK dout1_18 Vdout1_18ck191 = 1.8 time = 1920
.meas tran vdout1_18ck191 FIND v(dout1_18) AT=1920.05n

* CHECK dout1_19 Vdout1_19ck191 = 1.8 time = 1920
.meas tran vdout1_19ck191 FIND v(dout1_19) AT=1920.05n

* CHECK dout1_20 Vdout1_20ck191 = 0 time = 1920
.meas tran vdout1_20ck191 FIND v(dout1_20) AT=1920.05n

* CHECK dout1_21 Vdout1_21ck191 = 0 time = 1920
.meas tran vdout1_21ck191 FIND v(dout1_21) AT=1920.05n

* CHECK dout1_22 Vdout1_22ck191 = 0 time = 1920
.meas tran vdout1_22ck191 FIND v(dout1_22) AT=1920.05n

* CHECK dout1_23 Vdout1_23ck191 = 1.8 time = 1920
.meas tran vdout1_23ck191 FIND v(dout1_23) AT=1920.05n

* CHECK dout1_24 Vdout1_24ck191 = 0 time = 1920
.meas tran vdout1_24ck191 FIND v(dout1_24) AT=1920.05n

* CHECK dout1_25 Vdout1_25ck191 = 0 time = 1920
.meas tran vdout1_25ck191 FIND v(dout1_25) AT=1920.05n

* CHECK dout1_26 Vdout1_26ck191 = 1.8 time = 1920
.meas tran vdout1_26ck191 FIND v(dout1_26) AT=1920.05n

* CHECK dout1_27 Vdout1_27ck191 = 0 time = 1920
.meas tran vdout1_27ck191 FIND v(dout1_27) AT=1920.05n

* CHECK dout1_28 Vdout1_28ck191 = 0 time = 1920
.meas tran vdout1_28ck191 FIND v(dout1_28) AT=1920.05n

* CHECK dout1_29 Vdout1_29ck191 = 1.8 time = 1920
.meas tran vdout1_29ck191 FIND v(dout1_29) AT=1920.05n

* CHECK dout1_30 Vdout1_30ck191 = 0 time = 1920
.meas tran vdout1_30ck191 FIND v(dout1_30) AT=1920.05n

* CHECK dout1_31 Vdout1_31ck191 = 1.8 time = 1920
.meas tran vdout1_31ck191 FIND v(dout1_31) AT=1920.05n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 0 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 1.8 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 0 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 1.8 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 1.8 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 1930
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=1930.05n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 1930
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=1930.05n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 1930
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=1930.05n

* CHECK dout0_11 Vdout0_11ck192 = 0 time = 1930
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=1930.05n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 1930
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=1930.05n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 1930
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=1930.05n

* CHECK dout0_14 Vdout0_14ck192 = 0 time = 1930
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=1930.05n

* CHECK dout0_15 Vdout0_15ck192 = 0 time = 1930
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=1930.05n

* CHECK dout0_16 Vdout0_16ck192 = 0 time = 1930
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=1930.05n

* CHECK dout0_17 Vdout0_17ck192 = 1.8 time = 1930
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=1930.05n

* CHECK dout0_18 Vdout0_18ck192 = 1.8 time = 1930
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=1930.05n

* CHECK dout0_19 Vdout0_19ck192 = 0 time = 1930
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=1930.05n

* CHECK dout0_20 Vdout0_20ck192 = 1.8 time = 1930
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=1930.05n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 1930
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=1930.05n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 1930
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=1930.05n

* CHECK dout0_23 Vdout0_23ck192 = 1.8 time = 1930
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=1930.05n

* CHECK dout0_24 Vdout0_24ck192 = 0 time = 1930
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=1930.05n

* CHECK dout0_25 Vdout0_25ck192 = 1.8 time = 1930
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=1930.05n

* CHECK dout0_26 Vdout0_26ck192 = 0 time = 1930
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=1930.05n

* CHECK dout0_27 Vdout0_27ck192 = 1.8 time = 1930
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=1930.05n

* CHECK dout0_28 Vdout0_28ck192 = 1.8 time = 1930
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=1930.05n

* CHECK dout0_29 Vdout0_29ck192 = 1.8 time = 1930
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=1930.05n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 1930
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=1930.05n

* CHECK dout0_31 Vdout0_31ck192 = 1.8 time = 1930
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=1930.05n

* CHECK dout1_0 Vdout1_0ck192 = 0 time = 1930
.meas tran vdout1_0ck192 FIND v(dout1_0) AT=1930.05n

* CHECK dout1_1 Vdout1_1ck192 = 0 time = 1930
.meas tran vdout1_1ck192 FIND v(dout1_1) AT=1930.05n

* CHECK dout1_2 Vdout1_2ck192 = 1.8 time = 1930
.meas tran vdout1_2ck192 FIND v(dout1_2) AT=1930.05n

* CHECK dout1_3 Vdout1_3ck192 = 0 time = 1930
.meas tran vdout1_3ck192 FIND v(dout1_3) AT=1930.05n

* CHECK dout1_4 Vdout1_4ck192 = 0 time = 1930
.meas tran vdout1_4ck192 FIND v(dout1_4) AT=1930.05n

* CHECK dout1_5 Vdout1_5ck192 = 1.8 time = 1930
.meas tran vdout1_5ck192 FIND v(dout1_5) AT=1930.05n

* CHECK dout1_6 Vdout1_6ck192 = 1.8 time = 1930
.meas tran vdout1_6ck192 FIND v(dout1_6) AT=1930.05n

* CHECK dout1_7 Vdout1_7ck192 = 0 time = 1930
.meas tran vdout1_7ck192 FIND v(dout1_7) AT=1930.05n

* CHECK dout1_8 Vdout1_8ck192 = 0 time = 1930
.meas tran vdout1_8ck192 FIND v(dout1_8) AT=1930.05n

* CHECK dout1_9 Vdout1_9ck192 = 1.8 time = 1930
.meas tran vdout1_9ck192 FIND v(dout1_9) AT=1930.05n

* CHECK dout1_10 Vdout1_10ck192 = 0 time = 1930
.meas tran vdout1_10ck192 FIND v(dout1_10) AT=1930.05n

* CHECK dout1_11 Vdout1_11ck192 = 0 time = 1930
.meas tran vdout1_11ck192 FIND v(dout1_11) AT=1930.05n

* CHECK dout1_12 Vdout1_12ck192 = 0 time = 1930
.meas tran vdout1_12ck192 FIND v(dout1_12) AT=1930.05n

* CHECK dout1_13 Vdout1_13ck192 = 1.8 time = 1930
.meas tran vdout1_13ck192 FIND v(dout1_13) AT=1930.05n

* CHECK dout1_14 Vdout1_14ck192 = 1.8 time = 1930
.meas tran vdout1_14ck192 FIND v(dout1_14) AT=1930.05n

* CHECK dout1_15 Vdout1_15ck192 = 0 time = 1930
.meas tran vdout1_15ck192 FIND v(dout1_15) AT=1930.05n

* CHECK dout1_16 Vdout1_16ck192 = 1.8 time = 1930
.meas tran vdout1_16ck192 FIND v(dout1_16) AT=1930.05n

* CHECK dout1_17 Vdout1_17ck192 = 1.8 time = 1930
.meas tran vdout1_17ck192 FIND v(dout1_17) AT=1930.05n

* CHECK dout1_18 Vdout1_18ck192 = 0 time = 1930
.meas tran vdout1_18ck192 FIND v(dout1_18) AT=1930.05n

* CHECK dout1_19 Vdout1_19ck192 = 0 time = 1930
.meas tran vdout1_19ck192 FIND v(dout1_19) AT=1930.05n

* CHECK dout1_20 Vdout1_20ck192 = 0 time = 1930
.meas tran vdout1_20ck192 FIND v(dout1_20) AT=1930.05n

* CHECK dout1_21 Vdout1_21ck192 = 1.8 time = 1930
.meas tran vdout1_21ck192 FIND v(dout1_21) AT=1930.05n

* CHECK dout1_22 Vdout1_22ck192 = 1.8 time = 1930
.meas tran vdout1_22ck192 FIND v(dout1_22) AT=1930.05n

* CHECK dout1_23 Vdout1_23ck192 = 0 time = 1930
.meas tran vdout1_23ck192 FIND v(dout1_23) AT=1930.05n

* CHECK dout1_24 Vdout1_24ck192 = 1.8 time = 1930
.meas tran vdout1_24ck192 FIND v(dout1_24) AT=1930.05n

* CHECK dout1_25 Vdout1_25ck192 = 0 time = 1930
.meas tran vdout1_25ck192 FIND v(dout1_25) AT=1930.05n

* CHECK dout1_26 Vdout1_26ck192 = 1.8 time = 1930
.meas tran vdout1_26ck192 FIND v(dout1_26) AT=1930.05n

* CHECK dout1_27 Vdout1_27ck192 = 0 time = 1930
.meas tran vdout1_27ck192 FIND v(dout1_27) AT=1930.05n

* CHECK dout1_28 Vdout1_28ck192 = 0 time = 1930
.meas tran vdout1_28ck192 FIND v(dout1_28) AT=1930.05n

* CHECK dout1_29 Vdout1_29ck192 = 1.8 time = 1930
.meas tran vdout1_29ck192 FIND v(dout1_29) AT=1930.05n

* CHECK dout1_30 Vdout1_30ck192 = 1.8 time = 1930
.meas tran vdout1_30ck192 FIND v(dout1_30) AT=1930.05n

* CHECK dout1_31 Vdout1_31ck192 = 1.8 time = 1930
.meas tran vdout1_31ck192 FIND v(dout1_31) AT=1930.05n

* CHECK dout1_0 Vdout1_0ck194 = 0 time = 1950
.meas tran vdout1_0ck194 FIND v(dout1_0) AT=1950.05n

* CHECK dout1_1 Vdout1_1ck194 = 1.8 time = 1950
.meas tran vdout1_1ck194 FIND v(dout1_1) AT=1950.05n

* CHECK dout1_2 Vdout1_2ck194 = 0 time = 1950
.meas tran vdout1_2ck194 FIND v(dout1_2) AT=1950.05n

* CHECK dout1_3 Vdout1_3ck194 = 0 time = 1950
.meas tran vdout1_3ck194 FIND v(dout1_3) AT=1950.05n

* CHECK dout1_4 Vdout1_4ck194 = 0 time = 1950
.meas tran vdout1_4ck194 FIND v(dout1_4) AT=1950.05n

* CHECK dout1_5 Vdout1_5ck194 = 1.8 time = 1950
.meas tran vdout1_5ck194 FIND v(dout1_5) AT=1950.05n

* CHECK dout1_6 Vdout1_6ck194 = 0 time = 1950
.meas tran vdout1_6ck194 FIND v(dout1_6) AT=1950.05n

* CHECK dout1_7 Vdout1_7ck194 = 1.8 time = 1950
.meas tran vdout1_7ck194 FIND v(dout1_7) AT=1950.05n

* CHECK dout1_8 Vdout1_8ck194 = 1.8 time = 1950
.meas tran vdout1_8ck194 FIND v(dout1_8) AT=1950.05n

* CHECK dout1_9 Vdout1_9ck194 = 0 time = 1950
.meas tran vdout1_9ck194 FIND v(dout1_9) AT=1950.05n

* CHECK dout1_10 Vdout1_10ck194 = 0 time = 1950
.meas tran vdout1_10ck194 FIND v(dout1_10) AT=1950.05n

* CHECK dout1_11 Vdout1_11ck194 = 1.8 time = 1950
.meas tran vdout1_11ck194 FIND v(dout1_11) AT=1950.05n

* CHECK dout1_12 Vdout1_12ck194 = 0 time = 1950
.meas tran vdout1_12ck194 FIND v(dout1_12) AT=1950.05n

* CHECK dout1_13 Vdout1_13ck194 = 1.8 time = 1950
.meas tran vdout1_13ck194 FIND v(dout1_13) AT=1950.05n

* CHECK dout1_14 Vdout1_14ck194 = 0 time = 1950
.meas tran vdout1_14ck194 FIND v(dout1_14) AT=1950.05n

* CHECK dout1_15 Vdout1_15ck194 = 0 time = 1950
.meas tran vdout1_15ck194 FIND v(dout1_15) AT=1950.05n

* CHECK dout1_16 Vdout1_16ck194 = 0 time = 1950
.meas tran vdout1_16ck194 FIND v(dout1_16) AT=1950.05n

* CHECK dout1_17 Vdout1_17ck194 = 1.8 time = 1950
.meas tran vdout1_17ck194 FIND v(dout1_17) AT=1950.05n

* CHECK dout1_18 Vdout1_18ck194 = 1.8 time = 1950
.meas tran vdout1_18ck194 FIND v(dout1_18) AT=1950.05n

* CHECK dout1_19 Vdout1_19ck194 = 1.8 time = 1950
.meas tran vdout1_19ck194 FIND v(dout1_19) AT=1950.05n

* CHECK dout1_20 Vdout1_20ck194 = 0 time = 1950
.meas tran vdout1_20ck194 FIND v(dout1_20) AT=1950.05n

* CHECK dout1_21 Vdout1_21ck194 = 0 time = 1950
.meas tran vdout1_21ck194 FIND v(dout1_21) AT=1950.05n

* CHECK dout1_22 Vdout1_22ck194 = 0 time = 1950
.meas tran vdout1_22ck194 FIND v(dout1_22) AT=1950.05n

* CHECK dout1_23 Vdout1_23ck194 = 1.8 time = 1950
.meas tran vdout1_23ck194 FIND v(dout1_23) AT=1950.05n

* CHECK dout1_24 Vdout1_24ck194 = 0 time = 1950
.meas tran vdout1_24ck194 FIND v(dout1_24) AT=1950.05n

* CHECK dout1_25 Vdout1_25ck194 = 0 time = 1950
.meas tran vdout1_25ck194 FIND v(dout1_25) AT=1950.05n

* CHECK dout1_26 Vdout1_26ck194 = 1.8 time = 1950
.meas tran vdout1_26ck194 FIND v(dout1_26) AT=1950.05n

* CHECK dout1_27 Vdout1_27ck194 = 0 time = 1950
.meas tran vdout1_27ck194 FIND v(dout1_27) AT=1950.05n

* CHECK dout1_28 Vdout1_28ck194 = 0 time = 1950
.meas tran vdout1_28ck194 FIND v(dout1_28) AT=1950.05n

* CHECK dout1_29 Vdout1_29ck194 = 1.8 time = 1950
.meas tran vdout1_29ck194 FIND v(dout1_29) AT=1950.05n

* CHECK dout1_30 Vdout1_30ck194 = 0 time = 1950
.meas tran vdout1_30ck194 FIND v(dout1_30) AT=1950.05n

* CHECK dout1_31 Vdout1_31ck194 = 1.8 time = 1950
.meas tran vdout1_31ck194 FIND v(dout1_31) AT=1950.05n

* CHECK dout1_0 Vdout1_0ck195 = 0 time = 1960
.meas tran vdout1_0ck195 FIND v(dout1_0) AT=1960.05n

* CHECK dout1_1 Vdout1_1ck195 = 1.8 time = 1960
.meas tran vdout1_1ck195 FIND v(dout1_1) AT=1960.05n

* CHECK dout1_2 Vdout1_2ck195 = 1.8 time = 1960
.meas tran vdout1_2ck195 FIND v(dout1_2) AT=1960.05n

* CHECK dout1_3 Vdout1_3ck195 = 1.8 time = 1960
.meas tran vdout1_3ck195 FIND v(dout1_3) AT=1960.05n

* CHECK dout1_4 Vdout1_4ck195 = 1.8 time = 1960
.meas tran vdout1_4ck195 FIND v(dout1_4) AT=1960.05n

* CHECK dout1_5 Vdout1_5ck195 = 0 time = 1960
.meas tran vdout1_5ck195 FIND v(dout1_5) AT=1960.05n

* CHECK dout1_6 Vdout1_6ck195 = 1.8 time = 1960
.meas tran vdout1_6ck195 FIND v(dout1_6) AT=1960.05n

* CHECK dout1_7 Vdout1_7ck195 = 0 time = 1960
.meas tran vdout1_7ck195 FIND v(dout1_7) AT=1960.05n

* CHECK dout1_8 Vdout1_8ck195 = 1.8 time = 1960
.meas tran vdout1_8ck195 FIND v(dout1_8) AT=1960.05n

* CHECK dout1_9 Vdout1_9ck195 = 1.8 time = 1960
.meas tran vdout1_9ck195 FIND v(dout1_9) AT=1960.05n

* CHECK dout1_10 Vdout1_10ck195 = 0 time = 1960
.meas tran vdout1_10ck195 FIND v(dout1_10) AT=1960.05n

* CHECK dout1_11 Vdout1_11ck195 = 1.8 time = 1960
.meas tran vdout1_11ck195 FIND v(dout1_11) AT=1960.05n

* CHECK dout1_12 Vdout1_12ck195 = 1.8 time = 1960
.meas tran vdout1_12ck195 FIND v(dout1_12) AT=1960.05n

* CHECK dout1_13 Vdout1_13ck195 = 1.8 time = 1960
.meas tran vdout1_13ck195 FIND v(dout1_13) AT=1960.05n

* CHECK dout1_14 Vdout1_14ck195 = 0 time = 1960
.meas tran vdout1_14ck195 FIND v(dout1_14) AT=1960.05n

* CHECK dout1_15 Vdout1_15ck195 = 0 time = 1960
.meas tran vdout1_15ck195 FIND v(dout1_15) AT=1960.05n

* CHECK dout1_16 Vdout1_16ck195 = 0 time = 1960
.meas tran vdout1_16ck195 FIND v(dout1_16) AT=1960.05n

* CHECK dout1_17 Vdout1_17ck195 = 0 time = 1960
.meas tran vdout1_17ck195 FIND v(dout1_17) AT=1960.05n

* CHECK dout1_18 Vdout1_18ck195 = 1.8 time = 1960
.meas tran vdout1_18ck195 FIND v(dout1_18) AT=1960.05n

* CHECK dout1_19 Vdout1_19ck195 = 0 time = 1960
.meas tran vdout1_19ck195 FIND v(dout1_19) AT=1960.05n

* CHECK dout1_20 Vdout1_20ck195 = 1.8 time = 1960
.meas tran vdout1_20ck195 FIND v(dout1_20) AT=1960.05n

* CHECK dout1_21 Vdout1_21ck195 = 1.8 time = 1960
.meas tran vdout1_21ck195 FIND v(dout1_21) AT=1960.05n

* CHECK dout1_22 Vdout1_22ck195 = 0 time = 1960
.meas tran vdout1_22ck195 FIND v(dout1_22) AT=1960.05n

* CHECK dout1_23 Vdout1_23ck195 = 1.8 time = 1960
.meas tran vdout1_23ck195 FIND v(dout1_23) AT=1960.05n

* CHECK dout1_24 Vdout1_24ck195 = 1.8 time = 1960
.meas tran vdout1_24ck195 FIND v(dout1_24) AT=1960.05n

* CHECK dout1_25 Vdout1_25ck195 = 1.8 time = 1960
.meas tran vdout1_25ck195 FIND v(dout1_25) AT=1960.05n

* CHECK dout1_26 Vdout1_26ck195 = 1.8 time = 1960
.meas tran vdout1_26ck195 FIND v(dout1_26) AT=1960.05n

* CHECK dout1_27 Vdout1_27ck195 = 1.8 time = 1960
.meas tran vdout1_27ck195 FIND v(dout1_27) AT=1960.05n

* CHECK dout1_28 Vdout1_28ck195 = 0 time = 1960
.meas tran vdout1_28ck195 FIND v(dout1_28) AT=1960.05n

* CHECK dout1_29 Vdout1_29ck195 = 0 time = 1960
.meas tran vdout1_29ck195 FIND v(dout1_29) AT=1960.05n

* CHECK dout1_30 Vdout1_30ck195 = 0 time = 1960
.meas tran vdout1_30ck195 FIND v(dout1_30) AT=1960.05n

* CHECK dout1_31 Vdout1_31ck195 = 0 time = 1960
.meas tran vdout1_31ck195 FIND v(dout1_31) AT=1960.05n

* CHECK dout0_0 Vdout0_0ck197 = 0 time = 1980
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=1980.05n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 1980
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=1980.05n

* CHECK dout0_2 Vdout0_2ck197 = 1.8 time = 1980
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=1980.05n

* CHECK dout0_3 Vdout0_3ck197 = 1.8 time = 1980
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=1980.05n

* CHECK dout0_4 Vdout0_4ck197 = 0 time = 1980
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=1980.05n

* CHECK dout0_5 Vdout0_5ck197 = 1.8 time = 1980
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=1980.05n

* CHECK dout0_6 Vdout0_6ck197 = 1.8 time = 1980
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=1980.05n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 1980
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=1980.05n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 1980
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=1980.05n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 1980
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=1980.05n

* CHECK dout0_10 Vdout0_10ck197 = 1.8 time = 1980
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=1980.05n

* CHECK dout0_11 Vdout0_11ck197 = 0 time = 1980
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=1980.05n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 1980
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=1980.05n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 1980
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=1980.05n

* CHECK dout0_14 Vdout0_14ck197 = 0 time = 1980
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=1980.05n

* CHECK dout0_15 Vdout0_15ck197 = 0 time = 1980
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=1980.05n

* CHECK dout0_16 Vdout0_16ck197 = 0 time = 1980
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=1980.05n

* CHECK dout0_17 Vdout0_17ck197 = 1.8 time = 1980
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=1980.05n

* CHECK dout0_18 Vdout0_18ck197 = 1.8 time = 1980
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=1980.05n

* CHECK dout0_19 Vdout0_19ck197 = 0 time = 1980
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=1980.05n

* CHECK dout0_20 Vdout0_20ck197 = 1.8 time = 1980
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=1980.05n

* CHECK dout0_21 Vdout0_21ck197 = 1.8 time = 1980
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=1980.05n

* CHECK dout0_22 Vdout0_22ck197 = 0 time = 1980
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=1980.05n

* CHECK dout0_23 Vdout0_23ck197 = 1.8 time = 1980
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=1980.05n

* CHECK dout0_24 Vdout0_24ck197 = 0 time = 1980
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=1980.05n

* CHECK dout0_25 Vdout0_25ck197 = 1.8 time = 1980
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=1980.05n

* CHECK dout0_26 Vdout0_26ck197 = 0 time = 1980
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=1980.05n

* CHECK dout0_27 Vdout0_27ck197 = 1.8 time = 1980
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=1980.05n

* CHECK dout0_28 Vdout0_28ck197 = 1.8 time = 1980
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=1980.05n

* CHECK dout0_29 Vdout0_29ck197 = 1.8 time = 1980
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=1980.05n

* CHECK dout0_30 Vdout0_30ck197 = 1.8 time = 1980
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=1980.05n

* CHECK dout0_31 Vdout0_31ck197 = 1.8 time = 1980
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=1980.05n

* CHECK dout1_0 Vdout1_0ck198 = 0 time = 1990
.meas tran vdout1_0ck198 FIND v(dout1_0) AT=1990.05n

* CHECK dout1_1 Vdout1_1ck198 = 1.8 time = 1990
.meas tran vdout1_1ck198 FIND v(dout1_1) AT=1990.05n

* CHECK dout1_2 Vdout1_2ck198 = 1.8 time = 1990
.meas tran vdout1_2ck198 FIND v(dout1_2) AT=1990.05n

* CHECK dout1_3 Vdout1_3ck198 = 1.8 time = 1990
.meas tran vdout1_3ck198 FIND v(dout1_3) AT=1990.05n

* CHECK dout1_4 Vdout1_4ck198 = 1.8 time = 1990
.meas tran vdout1_4ck198 FIND v(dout1_4) AT=1990.05n

* CHECK dout1_5 Vdout1_5ck198 = 0 time = 1990
.meas tran vdout1_5ck198 FIND v(dout1_5) AT=1990.05n

* CHECK dout1_6 Vdout1_6ck198 = 1.8 time = 1990
.meas tran vdout1_6ck198 FIND v(dout1_6) AT=1990.05n

* CHECK dout1_7 Vdout1_7ck198 = 0 time = 1990
.meas tran vdout1_7ck198 FIND v(dout1_7) AT=1990.05n

* CHECK dout1_8 Vdout1_8ck198 = 1.8 time = 1990
.meas tran vdout1_8ck198 FIND v(dout1_8) AT=1990.05n

* CHECK dout1_9 Vdout1_9ck198 = 1.8 time = 1990
.meas tran vdout1_9ck198 FIND v(dout1_9) AT=1990.05n

* CHECK dout1_10 Vdout1_10ck198 = 0 time = 1990
.meas tran vdout1_10ck198 FIND v(dout1_10) AT=1990.05n

* CHECK dout1_11 Vdout1_11ck198 = 1.8 time = 1990
.meas tran vdout1_11ck198 FIND v(dout1_11) AT=1990.05n

* CHECK dout1_12 Vdout1_12ck198 = 1.8 time = 1990
.meas tran vdout1_12ck198 FIND v(dout1_12) AT=1990.05n

* CHECK dout1_13 Vdout1_13ck198 = 1.8 time = 1990
.meas tran vdout1_13ck198 FIND v(dout1_13) AT=1990.05n

* CHECK dout1_14 Vdout1_14ck198 = 0 time = 1990
.meas tran vdout1_14ck198 FIND v(dout1_14) AT=1990.05n

* CHECK dout1_15 Vdout1_15ck198 = 0 time = 1990
.meas tran vdout1_15ck198 FIND v(dout1_15) AT=1990.05n

* CHECK dout1_16 Vdout1_16ck198 = 0 time = 1990
.meas tran vdout1_16ck198 FIND v(dout1_16) AT=1990.05n

* CHECK dout1_17 Vdout1_17ck198 = 0 time = 1990
.meas tran vdout1_17ck198 FIND v(dout1_17) AT=1990.05n

* CHECK dout1_18 Vdout1_18ck198 = 1.8 time = 1990
.meas tran vdout1_18ck198 FIND v(dout1_18) AT=1990.05n

* CHECK dout1_19 Vdout1_19ck198 = 0 time = 1990
.meas tran vdout1_19ck198 FIND v(dout1_19) AT=1990.05n

* CHECK dout1_20 Vdout1_20ck198 = 1.8 time = 1990
.meas tran vdout1_20ck198 FIND v(dout1_20) AT=1990.05n

* CHECK dout1_21 Vdout1_21ck198 = 1.8 time = 1990
.meas tran vdout1_21ck198 FIND v(dout1_21) AT=1990.05n

* CHECK dout1_22 Vdout1_22ck198 = 0 time = 1990
.meas tran vdout1_22ck198 FIND v(dout1_22) AT=1990.05n

* CHECK dout1_23 Vdout1_23ck198 = 1.8 time = 1990
.meas tran vdout1_23ck198 FIND v(dout1_23) AT=1990.05n

* CHECK dout1_24 Vdout1_24ck198 = 1.8 time = 1990
.meas tran vdout1_24ck198 FIND v(dout1_24) AT=1990.05n

* CHECK dout1_25 Vdout1_25ck198 = 1.8 time = 1990
.meas tran vdout1_25ck198 FIND v(dout1_25) AT=1990.05n

* CHECK dout1_26 Vdout1_26ck198 = 1.8 time = 1990
.meas tran vdout1_26ck198 FIND v(dout1_26) AT=1990.05n

* CHECK dout1_27 Vdout1_27ck198 = 1.8 time = 1990
.meas tran vdout1_27ck198 FIND v(dout1_27) AT=1990.05n

* CHECK dout1_28 Vdout1_28ck198 = 0 time = 1990
.meas tran vdout1_28ck198 FIND v(dout1_28) AT=1990.05n

* CHECK dout1_29 Vdout1_29ck198 = 0 time = 1990
.meas tran vdout1_29ck198 FIND v(dout1_29) AT=1990.05n

* CHECK dout1_30 Vdout1_30ck198 = 0 time = 1990
.meas tran vdout1_30ck198 FIND v(dout1_30) AT=1990.05n

* CHECK dout1_31 Vdout1_31ck198 = 0 time = 1990
.meas tran vdout1_31ck198 FIND v(dout1_31) AT=1990.05n

* CHECK dout1_0 Vdout1_0ck200 = 0 time = 2010
.meas tran vdout1_0ck200 FIND v(dout1_0) AT=2010.05n

* CHECK dout1_1 Vdout1_1ck200 = 0 time = 2010
.meas tran vdout1_1ck200 FIND v(dout1_1) AT=2010.05n

* CHECK dout1_2 Vdout1_2ck200 = 0 time = 2010
.meas tran vdout1_2ck200 FIND v(dout1_2) AT=2010.05n

* CHECK dout1_3 Vdout1_3ck200 = 1.8 time = 2010
.meas tran vdout1_3ck200 FIND v(dout1_3) AT=2010.05n

* CHECK dout1_4 Vdout1_4ck200 = 1.8 time = 2010
.meas tran vdout1_4ck200 FIND v(dout1_4) AT=2010.05n

* CHECK dout1_5 Vdout1_5ck200 = 0 time = 2010
.meas tran vdout1_5ck200 FIND v(dout1_5) AT=2010.05n

* CHECK dout1_6 Vdout1_6ck200 = 0 time = 2010
.meas tran vdout1_6ck200 FIND v(dout1_6) AT=2010.05n

* CHECK dout1_7 Vdout1_7ck200 = 0 time = 2010
.meas tran vdout1_7ck200 FIND v(dout1_7) AT=2010.05n

* CHECK dout1_8 Vdout1_8ck200 = 1.8 time = 2010
.meas tran vdout1_8ck200 FIND v(dout1_8) AT=2010.05n

* CHECK dout1_9 Vdout1_9ck200 = 0 time = 2010
.meas tran vdout1_9ck200 FIND v(dout1_9) AT=2010.05n

* CHECK dout1_10 Vdout1_10ck200 = 1.8 time = 2010
.meas tran vdout1_10ck200 FIND v(dout1_10) AT=2010.05n

* CHECK dout1_11 Vdout1_11ck200 = 0 time = 2010
.meas tran vdout1_11ck200 FIND v(dout1_11) AT=2010.05n

* CHECK dout1_12 Vdout1_12ck200 = 0 time = 2010
.meas tran vdout1_12ck200 FIND v(dout1_12) AT=2010.05n

* CHECK dout1_13 Vdout1_13ck200 = 1.8 time = 2010
.meas tran vdout1_13ck200 FIND v(dout1_13) AT=2010.05n

* CHECK dout1_14 Vdout1_14ck200 = 1.8 time = 2010
.meas tran vdout1_14ck200 FIND v(dout1_14) AT=2010.05n

* CHECK dout1_15 Vdout1_15ck200 = 1.8 time = 2010
.meas tran vdout1_15ck200 FIND v(dout1_15) AT=2010.05n

* CHECK dout1_16 Vdout1_16ck200 = 0 time = 2010
.meas tran vdout1_16ck200 FIND v(dout1_16) AT=2010.05n

* CHECK dout1_17 Vdout1_17ck200 = 0 time = 2010
.meas tran vdout1_17ck200 FIND v(dout1_17) AT=2010.05n

* CHECK dout1_18 Vdout1_18ck200 = 0 time = 2010
.meas tran vdout1_18ck200 FIND v(dout1_18) AT=2010.05n

* CHECK dout1_19 Vdout1_19ck200 = 1.8 time = 2010
.meas tran vdout1_19ck200 FIND v(dout1_19) AT=2010.05n

* CHECK dout1_20 Vdout1_20ck200 = 1.8 time = 2010
.meas tran vdout1_20ck200 FIND v(dout1_20) AT=2010.05n

* CHECK dout1_21 Vdout1_21ck200 = 1.8 time = 2010
.meas tran vdout1_21ck200 FIND v(dout1_21) AT=2010.05n

* CHECK dout1_22 Vdout1_22ck200 = 1.8 time = 2010
.meas tran vdout1_22ck200 FIND v(dout1_22) AT=2010.05n

* CHECK dout1_23 Vdout1_23ck200 = 0 time = 2010
.meas tran vdout1_23ck200 FIND v(dout1_23) AT=2010.05n

* CHECK dout1_24 Vdout1_24ck200 = 1.8 time = 2010
.meas tran vdout1_24ck200 FIND v(dout1_24) AT=2010.05n

* CHECK dout1_25 Vdout1_25ck200 = 1.8 time = 2010
.meas tran vdout1_25ck200 FIND v(dout1_25) AT=2010.05n

* CHECK dout1_26 Vdout1_26ck200 = 0 time = 2010
.meas tran vdout1_26ck200 FIND v(dout1_26) AT=2010.05n

* CHECK dout1_27 Vdout1_27ck200 = 1.8 time = 2010
.meas tran vdout1_27ck200 FIND v(dout1_27) AT=2010.05n

* CHECK dout1_28 Vdout1_28ck200 = 0 time = 2010
.meas tran vdout1_28ck200 FIND v(dout1_28) AT=2010.05n

* CHECK dout1_29 Vdout1_29ck200 = 0 time = 2010
.meas tran vdout1_29ck200 FIND v(dout1_29) AT=2010.05n

* CHECK dout1_30 Vdout1_30ck200 = 1.8 time = 2010
.meas tran vdout1_30ck200 FIND v(dout1_30) AT=2010.05n

* CHECK dout1_31 Vdout1_31ck200 = 1.8 time = 2010
.meas tran vdout1_31ck200 FIND v(dout1_31) AT=2010.05n

* CHECK dout0_0 Vdout0_0ck201 = 0 time = 2020
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=2020.05n

* CHECK dout0_1 Vdout0_1ck201 = 1.8 time = 2020
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=2020.05n

* CHECK dout0_2 Vdout0_2ck201 = 1.8 time = 2020
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=2020.05n

* CHECK dout0_3 Vdout0_3ck201 = 1.8 time = 2020
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=2020.05n

* CHECK dout0_4 Vdout0_4ck201 = 1.8 time = 2020
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=2020.05n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 2020
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=2020.05n

* CHECK dout0_6 Vdout0_6ck201 = 1.8 time = 2020
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=2020.05n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 2020
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=2020.05n

* CHECK dout0_8 Vdout0_8ck201 = 1.8 time = 2020
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=2020.05n

* CHECK dout0_9 Vdout0_9ck201 = 1.8 time = 2020
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=2020.05n

* CHECK dout0_10 Vdout0_10ck201 = 0 time = 2020
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=2020.05n

* CHECK dout0_11 Vdout0_11ck201 = 1.8 time = 2020
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=2020.05n

* CHECK dout0_12 Vdout0_12ck201 = 1.8 time = 2020
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=2020.05n

* CHECK dout0_13 Vdout0_13ck201 = 1.8 time = 2020
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=2020.05n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 2020
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=2020.05n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 2020
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=2020.05n

* CHECK dout0_16 Vdout0_16ck201 = 0 time = 2020
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=2020.05n

* CHECK dout0_17 Vdout0_17ck201 = 0 time = 2020
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=2020.05n

* CHECK dout0_18 Vdout0_18ck201 = 1.8 time = 2020
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=2020.05n

* CHECK dout0_19 Vdout0_19ck201 = 0 time = 2020
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=2020.05n

* CHECK dout0_20 Vdout0_20ck201 = 1.8 time = 2020
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=2020.05n

* CHECK dout0_21 Vdout0_21ck201 = 1.8 time = 2020
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=2020.05n

* CHECK dout0_22 Vdout0_22ck201 = 0 time = 2020
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=2020.05n

* CHECK dout0_23 Vdout0_23ck201 = 1.8 time = 2020
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=2020.05n

* CHECK dout0_24 Vdout0_24ck201 = 1.8 time = 2020
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=2020.05n

* CHECK dout0_25 Vdout0_25ck201 = 1.8 time = 2020
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=2020.05n

* CHECK dout0_26 Vdout0_26ck201 = 1.8 time = 2020
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=2020.05n

* CHECK dout0_27 Vdout0_27ck201 = 1.8 time = 2020
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=2020.05n

* CHECK dout0_28 Vdout0_28ck201 = 0 time = 2020
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=2020.05n

* CHECK dout0_29 Vdout0_29ck201 = 0 time = 2020
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=2020.05n

* CHECK dout0_30 Vdout0_30ck201 = 0 time = 2020
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=2020.05n

* CHECK dout0_31 Vdout0_31ck201 = 0 time = 2020
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=2020.05n

* CHECK dout1_0 Vdout1_0ck201 = 0 time = 2020
.meas tran vdout1_0ck201 FIND v(dout1_0) AT=2020.05n

* CHECK dout1_1 Vdout1_1ck201 = 1.8 time = 2020
.meas tran vdout1_1ck201 FIND v(dout1_1) AT=2020.05n

* CHECK dout1_2 Vdout1_2ck201 = 1.8 time = 2020
.meas tran vdout1_2ck201 FIND v(dout1_2) AT=2020.05n

* CHECK dout1_3 Vdout1_3ck201 = 1.8 time = 2020
.meas tran vdout1_3ck201 FIND v(dout1_3) AT=2020.05n

* CHECK dout1_4 Vdout1_4ck201 = 1.8 time = 2020
.meas tran vdout1_4ck201 FIND v(dout1_4) AT=2020.05n

* CHECK dout1_5 Vdout1_5ck201 = 0 time = 2020
.meas tran vdout1_5ck201 FIND v(dout1_5) AT=2020.05n

* CHECK dout1_6 Vdout1_6ck201 = 1.8 time = 2020
.meas tran vdout1_6ck201 FIND v(dout1_6) AT=2020.05n

* CHECK dout1_7 Vdout1_7ck201 = 0 time = 2020
.meas tran vdout1_7ck201 FIND v(dout1_7) AT=2020.05n

* CHECK dout1_8 Vdout1_8ck201 = 1.8 time = 2020
.meas tran vdout1_8ck201 FIND v(dout1_8) AT=2020.05n

* CHECK dout1_9 Vdout1_9ck201 = 1.8 time = 2020
.meas tran vdout1_9ck201 FIND v(dout1_9) AT=2020.05n

* CHECK dout1_10 Vdout1_10ck201 = 0 time = 2020
.meas tran vdout1_10ck201 FIND v(dout1_10) AT=2020.05n

* CHECK dout1_11 Vdout1_11ck201 = 1.8 time = 2020
.meas tran vdout1_11ck201 FIND v(dout1_11) AT=2020.05n

* CHECK dout1_12 Vdout1_12ck201 = 1.8 time = 2020
.meas tran vdout1_12ck201 FIND v(dout1_12) AT=2020.05n

* CHECK dout1_13 Vdout1_13ck201 = 1.8 time = 2020
.meas tran vdout1_13ck201 FIND v(dout1_13) AT=2020.05n

* CHECK dout1_14 Vdout1_14ck201 = 0 time = 2020
.meas tran vdout1_14ck201 FIND v(dout1_14) AT=2020.05n

* CHECK dout1_15 Vdout1_15ck201 = 0 time = 2020
.meas tran vdout1_15ck201 FIND v(dout1_15) AT=2020.05n

* CHECK dout1_16 Vdout1_16ck201 = 0 time = 2020
.meas tran vdout1_16ck201 FIND v(dout1_16) AT=2020.05n

* CHECK dout1_17 Vdout1_17ck201 = 0 time = 2020
.meas tran vdout1_17ck201 FIND v(dout1_17) AT=2020.05n

* CHECK dout1_18 Vdout1_18ck201 = 1.8 time = 2020
.meas tran vdout1_18ck201 FIND v(dout1_18) AT=2020.05n

* CHECK dout1_19 Vdout1_19ck201 = 0 time = 2020
.meas tran vdout1_19ck201 FIND v(dout1_19) AT=2020.05n

* CHECK dout1_20 Vdout1_20ck201 = 1.8 time = 2020
.meas tran vdout1_20ck201 FIND v(dout1_20) AT=2020.05n

* CHECK dout1_21 Vdout1_21ck201 = 1.8 time = 2020
.meas tran vdout1_21ck201 FIND v(dout1_21) AT=2020.05n

* CHECK dout1_22 Vdout1_22ck201 = 0 time = 2020
.meas tran vdout1_22ck201 FIND v(dout1_22) AT=2020.05n

* CHECK dout1_23 Vdout1_23ck201 = 1.8 time = 2020
.meas tran vdout1_23ck201 FIND v(dout1_23) AT=2020.05n

* CHECK dout1_24 Vdout1_24ck201 = 1.8 time = 2020
.meas tran vdout1_24ck201 FIND v(dout1_24) AT=2020.05n

* CHECK dout1_25 Vdout1_25ck201 = 1.8 time = 2020
.meas tran vdout1_25ck201 FIND v(dout1_25) AT=2020.05n

* CHECK dout1_26 Vdout1_26ck201 = 1.8 time = 2020
.meas tran vdout1_26ck201 FIND v(dout1_26) AT=2020.05n

* CHECK dout1_27 Vdout1_27ck201 = 1.8 time = 2020
.meas tran vdout1_27ck201 FIND v(dout1_27) AT=2020.05n

* CHECK dout1_28 Vdout1_28ck201 = 0 time = 2020
.meas tran vdout1_28ck201 FIND v(dout1_28) AT=2020.05n

* CHECK dout1_29 Vdout1_29ck201 = 0 time = 2020
.meas tran vdout1_29ck201 FIND v(dout1_29) AT=2020.05n

* CHECK dout1_30 Vdout1_30ck201 = 0 time = 2020
.meas tran vdout1_30ck201 FIND v(dout1_30) AT=2020.05n

* CHECK dout1_31 Vdout1_31ck201 = 0 time = 2020
.meas tran vdout1_31ck201 FIND v(dout1_31) AT=2020.05n

* CHECK dout0_0 Vdout0_0ck202 = 1.8 time = 2030
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=2030.05n

* CHECK dout0_1 Vdout0_1ck202 = 1.8 time = 2030
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=2030.05n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 2030
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=2030.05n

* CHECK dout0_3 Vdout0_3ck202 = 1.8 time = 2030
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=2030.05n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 2030
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=2030.05n

* CHECK dout0_5 Vdout0_5ck202 = 1.8 time = 2030
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=2030.05n

* CHECK dout0_6 Vdout0_6ck202 = 1.8 time = 2030
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=2030.05n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 2030
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=2030.05n

* CHECK dout0_8 Vdout0_8ck202 = 1.8 time = 2030
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=2030.05n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 2030
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=2030.05n

* CHECK dout0_10 Vdout0_10ck202 = 1.8 time = 2030
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=2030.05n

* CHECK dout0_11 Vdout0_11ck202 = 1.8 time = 2030
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=2030.05n

* CHECK dout0_12 Vdout0_12ck202 = 0 time = 2030
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=2030.05n

* CHECK dout0_13 Vdout0_13ck202 = 0 time = 2030
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=2030.05n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 2030
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=2030.05n

* CHECK dout0_15 Vdout0_15ck202 = 1.8 time = 2030
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=2030.05n

* CHECK dout0_16 Vdout0_16ck202 = 1.8 time = 2030
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=2030.05n

* CHECK dout0_17 Vdout0_17ck202 = 1.8 time = 2030
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=2030.05n

* CHECK dout0_18 Vdout0_18ck202 = 1.8 time = 2030
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=2030.05n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 2030
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=2030.05n

* CHECK dout0_20 Vdout0_20ck202 = 1.8 time = 2030
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=2030.05n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 2030
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=2030.05n

* CHECK dout0_22 Vdout0_22ck202 = 1.8 time = 2030
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=2030.05n

* CHECK dout0_23 Vdout0_23ck202 = 1.8 time = 2030
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=2030.05n

* CHECK dout0_24 Vdout0_24ck202 = 0 time = 2030
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=2030.05n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 2030
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=2030.05n

* CHECK dout0_26 Vdout0_26ck202 = 0 time = 2030
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=2030.05n

* CHECK dout0_27 Vdout0_27ck202 = 0 time = 2030
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=2030.05n

* CHECK dout0_28 Vdout0_28ck202 = 1.8 time = 2030
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=2030.05n

* CHECK dout0_29 Vdout0_29ck202 = 1.8 time = 2030
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=2030.05n

* CHECK dout0_30 Vdout0_30ck202 = 1.8 time = 2030
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=2030.05n

* CHECK dout0_31 Vdout0_31ck202 = 0 time = 2030
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=2030.05n

* CHECK dout1_0 Vdout1_0ck202 = 1.8 time = 2030
.meas tran vdout1_0ck202 FIND v(dout1_0) AT=2030.05n

* CHECK dout1_1 Vdout1_1ck202 = 1.8 time = 2030
.meas tran vdout1_1ck202 FIND v(dout1_1) AT=2030.05n

* CHECK dout1_2 Vdout1_2ck202 = 1.8 time = 2030
.meas tran vdout1_2ck202 FIND v(dout1_2) AT=2030.05n

* CHECK dout1_3 Vdout1_3ck202 = 0 time = 2030
.meas tran vdout1_3ck202 FIND v(dout1_3) AT=2030.05n

* CHECK dout1_4 Vdout1_4ck202 = 0 time = 2030
.meas tran vdout1_4ck202 FIND v(dout1_4) AT=2030.05n

* CHECK dout1_5 Vdout1_5ck202 = 1.8 time = 2030
.meas tran vdout1_5ck202 FIND v(dout1_5) AT=2030.05n

* CHECK dout1_6 Vdout1_6ck202 = 0 time = 2030
.meas tran vdout1_6ck202 FIND v(dout1_6) AT=2030.05n

* CHECK dout1_7 Vdout1_7ck202 = 0 time = 2030
.meas tran vdout1_7ck202 FIND v(dout1_7) AT=2030.05n

* CHECK dout1_8 Vdout1_8ck202 = 1.8 time = 2030
.meas tran vdout1_8ck202 FIND v(dout1_8) AT=2030.05n

* CHECK dout1_9 Vdout1_9ck202 = 1.8 time = 2030
.meas tran vdout1_9ck202 FIND v(dout1_9) AT=2030.05n

* CHECK dout1_10 Vdout1_10ck202 = 1.8 time = 2030
.meas tran vdout1_10ck202 FIND v(dout1_10) AT=2030.05n

* CHECK dout1_11 Vdout1_11ck202 = 1.8 time = 2030
.meas tran vdout1_11ck202 FIND v(dout1_11) AT=2030.05n

* CHECK dout1_12 Vdout1_12ck202 = 0 time = 2030
.meas tran vdout1_12ck202 FIND v(dout1_12) AT=2030.05n

* CHECK dout1_13 Vdout1_13ck202 = 0 time = 2030
.meas tran vdout1_13ck202 FIND v(dout1_13) AT=2030.05n

* CHECK dout1_14 Vdout1_14ck202 = 1.8 time = 2030
.meas tran vdout1_14ck202 FIND v(dout1_14) AT=2030.05n

* CHECK dout1_15 Vdout1_15ck202 = 1.8 time = 2030
.meas tran vdout1_15ck202 FIND v(dout1_15) AT=2030.05n

* CHECK dout1_16 Vdout1_16ck202 = 1.8 time = 2030
.meas tran vdout1_16ck202 FIND v(dout1_16) AT=2030.05n

* CHECK dout1_17 Vdout1_17ck202 = 0 time = 2030
.meas tran vdout1_17ck202 FIND v(dout1_17) AT=2030.05n

* CHECK dout1_18 Vdout1_18ck202 = 0 time = 2030
.meas tran vdout1_18ck202 FIND v(dout1_18) AT=2030.05n

* CHECK dout1_19 Vdout1_19ck202 = 1.8 time = 2030
.meas tran vdout1_19ck202 FIND v(dout1_19) AT=2030.05n

* CHECK dout1_20 Vdout1_20ck202 = 0 time = 2030
.meas tran vdout1_20ck202 FIND v(dout1_20) AT=2030.05n

* CHECK dout1_21 Vdout1_21ck202 = 1.8 time = 2030
.meas tran vdout1_21ck202 FIND v(dout1_21) AT=2030.05n

* CHECK dout1_22 Vdout1_22ck202 = 0 time = 2030
.meas tran vdout1_22ck202 FIND v(dout1_22) AT=2030.05n

* CHECK dout1_23 Vdout1_23ck202 = 0 time = 2030
.meas tran vdout1_23ck202 FIND v(dout1_23) AT=2030.05n

* CHECK dout1_24 Vdout1_24ck202 = 0 time = 2030
.meas tran vdout1_24ck202 FIND v(dout1_24) AT=2030.05n

* CHECK dout1_25 Vdout1_25ck202 = 1.8 time = 2030
.meas tran vdout1_25ck202 FIND v(dout1_25) AT=2030.05n

* CHECK dout1_26 Vdout1_26ck202 = 1.8 time = 2030
.meas tran vdout1_26ck202 FIND v(dout1_26) AT=2030.05n

* CHECK dout1_27 Vdout1_27ck202 = 0 time = 2030
.meas tran vdout1_27ck202 FIND v(dout1_27) AT=2030.05n

* CHECK dout1_28 Vdout1_28ck202 = 1.8 time = 2030
.meas tran vdout1_28ck202 FIND v(dout1_28) AT=2030.05n

* CHECK dout1_29 Vdout1_29ck202 = 1.8 time = 2030
.meas tran vdout1_29ck202 FIND v(dout1_29) AT=2030.05n

* CHECK dout1_30 Vdout1_30ck202 = 1.8 time = 2030
.meas tran vdout1_30ck202 FIND v(dout1_30) AT=2030.05n

* CHECK dout1_31 Vdout1_31ck202 = 0 time = 2030
.meas tran vdout1_31ck202 FIND v(dout1_31) AT=2030.05n

* CHECK dout0_0 Vdout0_0ck203 = 1.8 time = 2040
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=2040.05n

* CHECK dout0_1 Vdout0_1ck203 = 1.8 time = 2040
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=2040.05n

* CHECK dout0_2 Vdout0_2ck203 = 1.8 time = 2040
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=2040.05n

* CHECK dout0_3 Vdout0_3ck203 = 0 time = 2040
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=2040.05n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 2040
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=2040.05n

* CHECK dout0_5 Vdout0_5ck203 = 1.8 time = 2040
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=2040.05n

* CHECK dout0_6 Vdout0_6ck203 = 0 time = 2040
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=2040.05n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 2040
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=2040.05n

* CHECK dout0_8 Vdout0_8ck203 = 1.8 time = 2040
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=2040.05n

* CHECK dout0_9 Vdout0_9ck203 = 1.8 time = 2040
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=2040.05n

* CHECK dout0_10 Vdout0_10ck203 = 1.8 time = 2040
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=2040.05n

* CHECK dout0_11 Vdout0_11ck203 = 1.8 time = 2040
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=2040.05n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 2040
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=2040.05n

* CHECK dout0_13 Vdout0_13ck203 = 0 time = 2040
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=2040.05n

* CHECK dout0_14 Vdout0_14ck203 = 1.8 time = 2040
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=2040.05n

* CHECK dout0_15 Vdout0_15ck203 = 1.8 time = 2040
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=2040.05n

* CHECK dout0_16 Vdout0_16ck203 = 1.8 time = 2040
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=2040.05n

* CHECK dout0_17 Vdout0_17ck203 = 0 time = 2040
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=2040.05n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 2040
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=2040.05n

* CHECK dout0_19 Vdout0_19ck203 = 1.8 time = 2040
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=2040.05n

* CHECK dout0_20 Vdout0_20ck203 = 0 time = 2040
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=2040.05n

* CHECK dout0_21 Vdout0_21ck203 = 1.8 time = 2040
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=2040.05n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 2040
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=2040.05n

* CHECK dout0_23 Vdout0_23ck203 = 0 time = 2040
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=2040.05n

* CHECK dout0_24 Vdout0_24ck203 = 0 time = 2040
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=2040.05n

* CHECK dout0_25 Vdout0_25ck203 = 1.8 time = 2040
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=2040.05n

* CHECK dout0_26 Vdout0_26ck203 = 1.8 time = 2040
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=2040.05n

* CHECK dout0_27 Vdout0_27ck203 = 0 time = 2040
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=2040.05n

* CHECK dout0_28 Vdout0_28ck203 = 1.8 time = 2040
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=2040.05n

* CHECK dout0_29 Vdout0_29ck203 = 1.8 time = 2040
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=2040.05n

* CHECK dout0_30 Vdout0_30ck203 = 1.8 time = 2040
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=2040.05n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 2040
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=2040.05n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
